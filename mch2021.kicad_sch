File: mch2021.kicad_sch (KiCad schematic)
At the start: 38 parts, among them J12 Hook 1, J13 Hook 2, J2 USB_C_Receptacle_USB2.0, J4 PMOD

Commit message: Bill of materials 1/2
Parts:
- D1: value USBLC6-4SC6 -> (none); footprint digikey-footprints:SOT23-6L -> (none); Sponsored N -> (none)
- D2: value RGB-5050 -> (none); footprint LED_SMD:LED_RGB_5050-6 -> (none); Category (none) -> LEDs; MPN (none) -> HL-AF-5060H271BU46FU79GC-S1-THL; Manufacturer (none) -> Honglitronic; Sponsored N -> (none)
- F1: value 1A -> (none); footprint Fuse:Fuse_0805_2012Metric -> (none); Category (none) -> Fuses; MPN (none) -> SMD0805B050TF; Manufacturer (none) -> Brightking Elec
- J12: value Hook 1 -> (none); footprint TestPoint:TestPoint_Keystone_5019_Minature -> (none); Category (none) -> Hooks
- J13: value Hook 2 -> (none); footprint TestPoint:TestPoint_Keystone_5019_Minature -> (none); Category (none) -> Hooks
- J2: value USB_C_Receptacle_USB2.0 -> (none); footprint Connector_USB:USB_C_Receptacle_HRO_TYPE-C-31-M-12 -> (none); Category (none) -> Connectors; MPN (none) -> TYPE-C-31-M-12; Manufacturer (none) -> Korean Hroparts Elec; Sponsored N -> (none)
- J4: value PMOD -> (none); footprint Connector_PinSocket_2.54mm:PinSocket_2x06_P2.54mm_Horizontal -> (none); Category (none) -> Connectors; MPN (none) -> A2541HWR-2x6P; Manufacturer (none) -> CJT; Sponsored N -> (none)
- N1, N5: value Logo -> (none); footprint custom:badgeteam -> (none); Category (none) -> PCB footprint only
- N2: value Artwork -> (none); footprint custom:vector7 -> (none); Category (none) -> PCB footprint only
- N4: value More Cool Hardware -> (none); footprint custom:protoboard-squares-big -> (none); Category (none) -> PCB footprint only
- R1, R2: value 5.1k -> (none); footprint Resistor_SMD:R_0402_1005Metric -> (none); Category (none) -> Resistors; Sponsored N -> (none)
- R22, R4, R5: value 47 -> (none); footprint Resistor_SMD:R_0402_1005Metric -> (none); Category (none) -> Resistors; LCSC C227095 -> (none); MPN AC0402FR-07470RL -> (none); Sponsored N -> (none)
- TP1, TP12, TP13: value LED OUT -> (none); footprint TestPoint:TestPoint_Pad_1.0x1.0mm -> (none); Buy early (none) -> N; Category (none) -> Testpoints; Sponsored (none) -> N
- TP10: value RR -> (none); footprint TestPoint:TestPoint_Pad_1.0x1.0mm -> (none); Buy early (none) -> N; Category (none) -> Testpoints; Sponsored (none) -> N
- TP11, TP29, TP30: value RB -> (none); footprint TestPoint:TestPoint_Pad_1.0x1.0mm -> (none); Buy early (none) -> N; Category (none) -> Testpoints; Sponsored (none) -> N
- TP18: value Vbatt -> (none); footprint TestPoint:TestPoint_Pad_1.0x1.0mm -> (none); Buy early (none) -> N; Category (none) -> Testpoints; Sponsored (none) -> N
- TP19: value 3.3v -> (none); footprint TestPoint:TestPoint_Pad_1.0x1.0mm -> (none); Buy early (none) -> N; Category (none) -> Testpoints; Sponsored (none) -> N
- TP20, TP26: value GND -> (none); footprint TestPoint:TestPoint_Pad_1.0x1.0mm -> (none); Buy early (none) -> N; Category (none) -> Testpoints; Sponsored (none) -> N
- TP21: value I2S_MCLK -> (none); footprint TestPoint:TestPoint_Pad_1.0x1.0mm -> (none); Buy early (none) -> N; Category (none) -> Testpoints; Sponsored (none) -> N
- TP22: value I2S_DATA -> (none); footprint TestPoint:TestPoint_Pad_1.0x1.0mm -> (none); Buy early (none) -> N; Category (none) -> Testpoints; Sponsored (none) -> N
- TP23: value sSDA -> (none); footprint TestPoint:TestPoint_Pad_1.0x1.0mm -> (none); Buy early (none) -> N; Category (none) -> Testpoints; Sponsored (none) -> N
- TP24: value sSCL -> (none); footprint TestPoint:TestPoint_Pad_1.0x1.0mm -> (none); Buy early (none) -> N; Category (none) -> Testpoints; Sponsored (none) -> N
- TP25: value I2S_CLK -> (none); footprint TestPoint:TestPoint_Pad_1.0x1.0mm -> (none); Buy early (none) -> N; Category (none) -> Testpoints; Sponsored (none) -> N
- TP28: value I2S_LR -> (none); footprint TestPoint:TestPoint_Pad_1.0x1.0mm -> (none); Buy early (none) -> N; Category (none) -> Testpoints; Sponsored (none) -> N
- TP4: value LM -> (none); footprint TestPoint:TestPoint_Pad_1.0x1.0mm -> (none); Buy early (none) -> N; Category (none) -> Testpoints; Sponsored (none) -> N
- TP5: value LR -> (none); footprint TestPoint:TestPoint_Pad_1.0x1.0mm -> (none); Buy early (none) -> N; Category (none) -> Testpoints; Sponsored (none) -> N
- TP6: value LB -> (none); footprint TestPoint:TestPoint_Pad_1.0x1.0mm -> (none); Buy early (none) -> N; Category (none) -> Testpoints; Sponsored (none) -> N
- TP7: value RX -> (none); footprint TestPoint:TestPoint_Pad_1.0x1.0mm -> (none); Buy early (none) -> N; Category (none) -> Testpoints; Sponsored (none) -> N
- TP8: value TX -> (none); footprint TestPoint:TestPoint_Pad_1.0x1.0mm -> (none); Buy early (none) -> N; Category (none) -> Testpoints; Sponsored (none) -> N

Commit message: Add more info to BOM
Parts:
- D1, D2, F1, J2, R1, R2, R22, R4, R5: Buy early (none) -> Y; Sponsored (none) -> N
- J12, J13: Sponsored (none) -> N
- J4, N1, N2, N4, N5: Buy early (none) -> N; Sponsored (none) -> N
Changed lines of the file:
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@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Sponsored" "" (id 7) (at 25.4 43.18 0)
+    (property "Sponsored" "N" (id 7) (at 25.4 43.18 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     )
     (property "Manufacturer" "Korean Hroparts Elec" (id 10) (at 25.4 43.18 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Buy early" "Y" (id 11) (at 25.4 43.18 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Sponsored" "" (id 7) (at 45.72 35.56 0)
+    (property "Sponsored" "N" (id 7) (at 45.72 35.56 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     )
     (property "Category" "Resistors" (id 10) (at 45.72 35.56 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Buy early" "Y" (id 11) (at 45.72 35.56 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Description" "Generic part" (id 12) (at 45.72 35.56 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Sponsored" "" (id 7) (at 45.72 33.02 0)
+    (property "Sponsored" "N" (id 7) (at 45.72 33.02 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     )
     (property "Category" "Resistors" (id 10) (at 45.72 33.02 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Buy early" "Y" (id 11) (at 45.72 33.02 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Description" "Generic part" (id 12) (at 45.72 33.02 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Sponsored" "" (id 14) (at 52.07 63.5 0)
+    (property "Sponsored" "N" (id 14) (at 52.07 63.5 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Buy early" "Y" (id 15) (at 52.07 63.5 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Sponsored" "" (id 7) (at 255.27 148.59 0)
+    (property "Sponsored" "N" (id 7) (at 255.27 148.59 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     )
     (property "Category" "Connectors" (id 11) (at 255.27 148.59 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Buy early" "N" (id 12) (at 255.27 148.59 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Buy early" "N" (id 5) (at 23.495 189.865 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Sponsored" "N" (id 6) (at 23.495 189.865 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
   )
   (symbol (lib_id "mch2021-rescue:Polyfuse_Small-Device") (at 54.61 27.94 270) (unit 1)
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Buy early" "Y" (id 9) (at 54.61 27.94 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Sponsored" "N" (id 10) (at 54.61 27.94 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
     )
     (property "Category" "PCB footprint only" (id 4) (at 24.13 163.195 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Buy early" "N" (id 5) (at 24.13 163.195 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Sponsored" "N" (id 6) (at 24.13 163.195 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Buy early" "N" (id 5) (at 23.622 181.102 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Sponsored" "N" (id 6) (at 23.622 181.102 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
   )
   (symbol (lib_id "mch2021-rescue:Housing-Mechanical") (at 24.13 172.085 0) (unit 1)
@@
     )
     (property "Category" "PCB footprint only" (id 4) (at 24.13 172.085 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Buy early" "N" (id 5) (at 24.13 172.085 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Sponsored" "N" (id 6) (at 24.13 172.085 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Sponsored" "" (id 7) (at 165.1 156.21 0)
+    (property "Sponsored" "N" (id 7) (at 165.1 156.21 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     )
     (property "Manufacturer" "Honglitronic" (id 11) (at 165.1 156.21 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Buy early" "Y" (id 12) (at 165.1 156.21 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Sponsored" "N" (id 6) (at 154.94 189.23 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
   )
@@
     )
     (property "Description" "Same as on CampZone 2019 badge, tbd" (id 5) (at 154.94 184.15 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Sponsored" "N" (id 6) (at 154.94 184.15 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Sponsored" "" (id 7) (at 152.4 111.76 0)
+    (property "Sponsored" "N" (id 7) (at 152.4 111.76 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     )
     (property "Category" "Resistors" (id 10) (at 152.4 111.76 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Buy early" "Y" (id 11) (at 152.4 111.76 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Description" "Generic part" (id 12) (at 152.4 111.76 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Sponsored" "" (id 7) (at 148.59 111.76 0)
+    (property "Sponsored" "N" (id 7) (at 148.59 111.76 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     )
     (property "Category" "Resistors" (id 10) (at 148.59 111.76 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Buy early" "Y" (id 11) (at 148.59 111.76 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Description" "Generic part" (id 12) (at 148.59 111.76 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Sponsored" "" (id 7) (at 144.78 111.76 0)
+    (property "Sponsored" "N" (id 7) (at 144.78 111.76 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     )
     (property "Category" "Resistors" (id 10) (at 144.78 111.76 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Buy early" "Y" (id 11) (at 144.78 111.76 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Description" "Generic part" (id 12) (at 144.78 111.76 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     )
     (path "/00000000-0000-0000-0000-00005fdc6c76/00000000-0000-0000-0000-00006005561c"
-      (reference "Q1") (unit 1) (value "Q_NMOS_GSD") (footprint "Package_TO_SOT_SMD:SOT-23")
+      (reference "Q1") (unit 1) (value "AP2302B") (footprint "Package_TO_SOT_SMD:SOT-23")
     )
     (path "/00000000-0000-0000-0000-00005fdc6c76/00000000-0000-0000-0000-0000601ec337"
-      (reference "Q2") (unit 1) (value "Q_NMOS_GSD") (footprint "Package_TO_SOT_SMD:SOT-23")
+      (reference "Q2") (unit 1) (value "AP2302B") (footprint "Package_TO_SOT_SMD:SOT-23")
     )
     (path "/00000000-0000-0000-0000-00005e9eb87a"
@@
       (reference "R52") (unit 1) (value "4.7") (footprint "Resistor_SMD:R_0402_1005Metric")
     )
+    (path "/00000000-0000-0000-0000-000060c789de/0beaab9e-e6f7-41fa-8d26-3b42fbddf08d"
+      (reference "R53") (unit 1) (value "1k") (footprint "Resistor_SMD:R_0402_1005Metric")
+    )
     (path "/00000000-0000-0000-0000-000060c789de/00000000-0000-0000-0000-000060c79cc7"
-      (reference "R56") (unit 1) (value "2k") (footprint "Resistor_SMD:R_0402_1005Metric")
+      (reference "R56") (unit 1) (value "1k") (footprint "Resistor_SMD:R_0402_1005Metric")
     )
     (path "/00000000-0000-0000-0000-000060c789de/00000000-0000-0000-0000-00005fceba12"
@@
     )
     (path "/00000000-0000-0000-0000-000060c789de/00000000-0000-0000-0000-00005fc35b86"
-      (reference "R63") (unit 1) (value "3k4") (footprint "Resistor_SMD:R_0402_1005Metric")
+      (reference "R63") (unit 1) (value "4.7k") (footprint "Resistor_SMD:R_0402_1005Metric")
     )
     (path "/00000000-0000-0000-0000-000060c789de/00000000-0000-0000-0000-00005fceba13"

Commit message: Add IR transmitter, modify bill of materials
Parts:
- removed J12, J13: (no value), symbol Connector_Generic:Conn_01x01
Other:
- sheet AUDIO ports: added none; removed SPK_DISABLED
- sheet RP2040 ports: added none; removed SPK_DISABLE
