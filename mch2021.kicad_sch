File: mch2021.kicad_sch (KiCad schematic)
At the start: 32 parts, among them J12 Hook 1, J13 Hook 2, J2 USB_C_Receptacle_USB2.0, J4 PMOD

Commit message: Add amplifier and spekaer, fixes
Parts:
- added TP21: I2S_MCLK, TestPoint:TestPoint_Pad_1.0x1.0mm, symbol mch2021-rescue:TestPoint_Small-Connector
- added TP22: I2S_DATA, TestPoint:TestPoint_Pad_1.0x1.0mm, symbol mch2021-rescue:TestPoint_Small-Connector
- added TP25: I2S_CLK, TestPoint:TestPoint_Pad_1.0x1.0mm, symbol mch2021-rescue:TestPoint_Small-Connector
- added TP28: I2S_LR, TestPoint:TestPoint_Pad_1.0x1.0mm, symbol mch2021-rescue:TestPoint_Small-Connector
Connections:
- new net AUDIO/I2S_CLK: TP28.1
- new net AUDIO/I2S_DATA: TP22.1
- new net AUDIO/I2S_LR: TP25.1
- new net AUDIO/I2S_MCLK: TP21.1
Other:
- added sheet AUDIO (audio.kicad_sch)
- sheet ESP32 ports: added I2S_MCLK; removed none
- moved on the sheet: N1, N2, N4, N5

Commit message: Finishing touches for audio circuit
Parts:
- added TP29, TP30: RB, TestPoint:TestPoint_Pad_1.0x1.0mm, symbol mch2021-rescue:TestPoint_Small-Connector
Connections:
- net AUDIO/I2S_MCLK: no longer TP21.1
- new net RP2040/SAO_IO2: TP29.1
- new net RP2040/SAO_IO3: TP30.1
Other:
- sheet RP2040 ports: added SAO_IO2, SAO_IO3, SPK_DISABLE; removed LCD_RESET

Commit message: Add some footprints
Other:
- moved on the sheet: N2, N4, N5
Changed lines of the file:
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@@
     (pin "1")
   )
-  (symbol (lib_id "mch2021-rescue:Housing-Mechanical") (at 22.352 189.992 0) (unit 1)
-    (in_bom yes) (on_board yes)
-    (property "Reference" "N2" (id 0) (at 26.2382 189.1284 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Value" "Artwork" (id 1) (at 26.2382 191.4398 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Footprint" "custom:vector7" (id 2) (at 23.622 188.722 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "~" (id 3) (at 23.622 188.722 0)
+  (symbol (lib_id "mch2021-rescue:Housing-Mechanical") (at 23.495 189.865 0) (unit 1)
+    (in_bom yes) (on_board yes)
+    (property "Reference" "N2" (id 0) (at 27.3812 189.0014 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "Artwork" (id 1) (at 27.3812 191.3128 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "custom:vector7" (id 2) (at 24.765 188.595 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (id 3) (at 24.765 188.595 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     (pin "2")
   )
-  (symbol (lib_id "mch2021-rescue:Housing-Mechanical") (at 23.622 163.322 0) (unit 1)
-    (in_bom yes) (on_board yes)
-    (property "Reference" "N4" (id 0) (at 27.5082 162.4584 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Value" "More Cool Hardware" (id 1) (at 27.5082 164.7698 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Footprint" "custom:protoboard-squares-big" (id 2) (at 24.892 162.052 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "~" (id 3) (at 24.892 162.052 0)
+  (symbol (lib_id "mch2021-rescue:Housing-Mechanical") (at 24.13 163.195 0) (unit 1)
+    (in_bom yes) (on_board yes)
+    (property "Reference" "N4" (id 0) (at 28.0162 162.3314 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "More Cool Hardware" (id 1) (at 28.0162 164.6428 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "custom:protoboard-squares-big" (id 2) (at 25.4 161.925 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (id 3) (at 25.4 161.925 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     )
   )
-  (symbol (lib_id "mch2021-rescue:Housing-Mechanical") (at 23.622 172.212 0) (unit 1)
-    (in_bom yes) (on_board yes)
-    (property "Reference" "N5" (id 0) (at 27.5082 171.3484 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Value" "Logo" (id 1) (at 27.5082 173.6598 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Footprint" "custom:badgeteam" (id 2) (at 24.892 170.942 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "~" (id 3) (at 24.892 170.942 0)
+  (symbol (lib_id "mch2021-rescue:Housing-Mechanical") (at 24.13 172.085 0) (unit 1)
+    (in_bom yes) (on_board yes)
+    (property "Reference" "N5" (id 0) (at 28.0162 171.2214 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "Logo" (id 1) (at 28.0162 173.5328 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "custom:badgeteam" (id 2) (at 25.4 170.815 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (id 3) (at 25.4 170.815 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     )
   )
-  (sheet (at 92.71 78.74) (size 44.45 10.16) (fields_autoplaced)
+  (sheet (at 124.46 78.74) (size 12.7 9.525) (fields_autoplaced)
     (stroke (width 0) (type solid) (color 0 0 0 0))
     (fill (color 0 0 0 0.0000))
-    (property "Sheet name" "I2C peripherals" (id 0) (at 92.71 78.0284 0)
+    (property "Sheet name" "I2C peripherals" (id 0) (at 124.46 78.0284 0)
       (effects (font (size 1.27 1.27)) (justify left bottom))
     )
-    (property "Sheet file" "bosch.kicad_sch" (id 1) (at 92.71 89.4846 0)
+    (property "Sheet file" "bosch.kicad_sch" (id 1) (at 124.46 88.8496 0)
       (effects (font (size 1.27 1.27)) (justify left top))
     )
@@
     )
     (path "/8ec93f95-b65c-4f0d-a4f4-32395a9e162a/f643a4c0-3ade-40ba-832b-368dbefe1c13"
-      (reference "LS1") (unit 1) (value "Speaker") (footprint "")
+      (reference "LS1") (unit 1) (value "Speaker") (footprint "Connector_Molex:Molex_PicoBlade_53261-0271_1x02-1MP_P1.25mm_Horizontal")
     )
     (path "/00000000-0000-0000-0000-0000600b192e"
@@
     )
     (path "/8ec93f95-b65c-4f0d-a4f4-32395a9e162a/51e1c19d-f8a7-4a1a-b1e8-cef5ae8d7825"
-      (reference "U1") (unit 1) (value "CS4344-CZZ") (footprint "CS4344-CZZ:SOP50P490X110-10N")
+      (reference "U1") (unit 1) (value "MS4344") (footprint "CS4344-CZZ:SOP50P490X110-10N")
     )
     (path "/00000000-0000-0000-0000-00005fdc6c76/00000000-0000-0000-0000-00005fe0ff4d"
@@
     )
     (path "/8ec93f95-b65c-4f0d-a4f4-32395a9e162a/26019028-e3d5-4d95-ab65-c576634e257a"
-      (reference "U4") (unit 1) (value "TDA2822") (footprint "")
+      (reference "U4") (unit 1) (value "D2822M") (footprint "Package_SO:SOP-8_3.9x4.9mm_P1.27mm")
     )
     (path "/8ec93f95-b65c-4f0d-a4f4-32395a9e162a/8160ad40-29a8-46f1-84fa-751d39cb5563"
-      (reference "U4") (unit 2) (value "TDA2822") (footprint "")
+      (reference "U4") (unit 2) (value "D2822M") (footprint "Package_SO:SOP-8_3.9x4.9mm_P1.27mm")
     )
     (path "/8ec93f95-b65c-4f0d-a4f4-32395a9e162a/d97ab6f3-2ddb-415c-b16e-0432924347ee"
-      (reference "U4") (unit 3) (value "TDA2822") (footprint "")
+      (reference "U4") (unit 3) (value "D2822M") (footprint "Package_SO:SOP-8_3.9x4.9mm_P1.27mm")
     )
     (path "/00000000-0000-0000-0000-00005f526357/00000000-0000-0000-0000-00005f52b856"
