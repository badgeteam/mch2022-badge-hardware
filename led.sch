File: led.sch (KiCad schematic (older format))
At the start: 12 parts, among them U10 74LVC1G125

Commit message: Add chokes to usb lines
Connections:
- net VIN is gone; now on net PWR_LED: U10.5 (VCC)
Changed lines of the file:
@@
 $Descr A4 11693 8268
 encoding utf-8
-Sheet 4 9
+Sheet 8 9
 Title ""
 Date "2020-12-13"
@@
 $EndComp
 $Comp
-L vin:VIN #PWR?
-U 1 1 60345F4A
-P 3150 3650
-AR Path="/5F51E414/60345F4A" Ref="#PWR?"  Part="1"
-AR Path="/612408B6/60345F4A" Ref="#PWR0212"  Part="1"
-F 0 "#PWR0212" H 3160 3650 20  0001 C CNN
-F 1 "VIN" H 3150 3746 40  0000 C CNN
-F 2 "" H 3150 3650 60  0001 C CNN
-F 3 "" H 3150 3650 60  0001 C CNN
-	1    3150 3650
-	-1   0    0    -1
-$EndComp
-$Comp
 L power:GND #PWR?
 U 1 1 60345F44
@@
 Text HLabel 2000 4150 0    79   Input ~ 0
 DATA_IN2
+Text GLabel 3150 3650 1    39   Input ~ 0
+PWR_LED
 $EndSCHEMATC

Commit message: Updated schematic, add design file
Parts:
- removed R68: 220, Resistor_SMD:R_0603_1608Metric, symbol Device:R_Small
- D4, D5, D6, D7, D8, D9: value WS2812B -> WS2812B-2020; footprint LED_SMD:LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm -> custom:ws2812-2020; LCSC C139127 -> C965555
- R67: value 220 -> 470
Connections:
- net DATA_IN2: now also R67.1, U10.2 (A)
Changed lines of the file:
@@
 P 4300 4050
 F 0 "D4" H 4100 4300 50  0000 L CNN
-F 1 "WS2812B" V 4450 4300 50  0000 L CNN
-F 2 "LED_SMD:LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm" H 4350 3750 50  0001 L TNN
-F 3 "https://cdn-shop.adafruit.com/datasheets/WS2812B.pdf" H 4400 3675 50  0001 L TNN
-F 4 "C139127" H 4300 4050 50  0001 C CNN "LCSC"
+F 1 "WS2812B-2020" V 4450 4300 50  0000 L CNN
+F 2 "custom:ws2812-2020" H 4350 3750 50  0001 L TNN
+F 3 "https://datasheet.lcsc.com/szlcsc/2012110135_Worldsemi-WS2812B-2020_C965555.pdf" H 4400 3675 50  0001 L TNN
+F 4 "C965555" H 4300 4050 50  0001 C CNN "LCSC"
 F 5 "-" H 4300 4050 50  0001 C CNN "Mouser"
 F 6 "" H 4300 4050 50  0001 C CNN "Price"
@@
 P 4900 4050
 F 0 "D5" H 4700 4300 50  0000 L CNN
-F 1 "WS2812B" V 5050 4300 50  0000 L CNN
-F 2 "LED_SMD:LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm" H 4950 3750 50  0001 L TNN
-F 3 "https://cdn-shop.adafruit.com/datasheets/WS2812B.pdf" H 5000 3675 50  0001 L TNN
-F 4 "C139127" H 4900 4050 50  0001 C CNN "LCSC"
+F 1 "WS2812B-2020" V 5050 4300 50  0000 L CNN
+F 2 "custom:ws2812-2020" H 4950 3750 50  0001 L TNN
+F 3 "https://datasheet.lcsc.com/szlcsc/2012110135_Worldsemi-WS2812B-2020_C965555.pdf" H 5000 3675 50  0001 L TNN
+F 4 "C965555" H 4900 4050 50  0001 C CNN "LCSC"
 F 5 "-" H 4900 4050 50  0001 C CNN "Mouser"
 F 6 "" H 4900 4050 50  0001 C CNN "Price"
@@
 P 5500 4050
 F 0 "D6" H 5300 4300 50  0000 L CNN
-F 1 "WS2812B" V 5650 4300 50  0000 L CNN
-F 2 "LED_SMD:LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm" H 5550 3750 50  0001 L TNN
-F 3 "https://cdn-shop.adafruit.com/datasheets/WS2812B.pdf" H 5600 3675 50  0001 L TNN
-F 4 "C139127" H 5500 4050 50  0001 C CNN "LCSC"
+F 1 "WS2812B-2020" V 5650 4300 50  0000 L CNN
+F 2 "custom:ws2812-2020" H 5550 3750 50  0001 L TNN
+F 3 "https://datasheet.lcsc.com/szlcsc/2012110135_Worldsemi-WS2812B-2020_C965555.pdf" H 5600 3675 50  0001 L TNN
+F 4 "C965555" H 5500 4050 50  0001 C CNN "LCSC"
 F 5 "-" H 5500 4050 50  0001 C CNN "Mouser"
 F 6 "" H 5500 4050 50  0001 C CNN "Price"
@@
 P 6100 4050
 F 0 "D7" H 5900 4300 50  0000 L CNN
-F 1 "WS2812B" V 6250 4300 50  0000 L CNN
-F 2 "LED_SMD:LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm" H 6150 3750 50  0001 L TNN
-F 3 "https://cdn-shop.adafruit.com/datasheets/WS2812B.pdf" H 6200 3675 50  0001 L TNN
-F 4 "C139127" H 6100 4050 50  0001 C CNN "LCSC"
+F 1 "WS2812B-2020" V 6250 4300 50  0000 L CNN
+F 2 "custom:ws2812-2020" H 6150 3750 50  0001 L TNN
+F 3 "https://datasheet.lcsc.com/szlcsc/2012110135_Worldsemi-WS2812B-2020_C965555.pdf" H 6200 3675 50  0001 L TNN
+F 4 "C965555" H 6100 4050 50  0001 C CNN "LCSC"
 F 5 "-" H 6100 4050 50  0001 C CNN "Mouser"
 F 6 "" H 6100 4050 50  0001 C CNN "Price"
@@
 P 6700 4050
 F 0 "D8" H 6500 4300 50  0000 L CNN
-F 1 "WS2812B" V 6850 4300 50  0000 L CNN
-F 2 "LED_SMD:LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm" H 6750 3750 50  0001 L TNN
-F 3 "https://cdn-shop.adafruit.com/datasheets/WS2812B.pdf" H 6800 3675 50  0001 L TNN
-F 4 "C139127" H 6700 4050 50  0001 C CNN "LCSC"
+F 1 "WS2812B-2020" V 6850 4300 50  0000 L CNN
+F 2 "custom:ws2812-2020" H 6750 3750 50  0001 L TNN
+F 3 "https://datasheet.lcsc.com/szlcsc/2012110135_Worldsemi-WS2812B-2020_C965555.pdf" H 6800 3675 50  0001 L TNN
+F 4 "C965555" H 6700 4050 50  0001 C CNN "LCSC"
 F 5 "-" H 6700 4050 50  0001 C CNN "Mouser"
 F 6 "" H 6700 4050 50  0001 C CNN "Price"
@@
 P 7300 4050
 F 0 "D9" H 7100 4300 50  0000 L CNN
-F 1 "WS2812B" V 7450 4300 50  0000 L CNN
-F 2 "LED_SMD:LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm" H 7350 3750 50  0001 L TNN
-F 3 "https://cdn-shop.adafruit.com/datasheets/WS2812B.pdf" H 7400 3675 50  0001 L TNN
-F 4 "C139127" H 7300 4050 50  0001 C CNN "LCSC"
+F 1 "WS2812B-2020" V 7450 4300 50  0000 L CNN
+F 2 "custom:ws2812-2020" H 7350 3750 50  0001 L TNN
+F 3 "https://datasheet.lcsc.com/szlcsc/2012110135_Worldsemi-WS2812B-2020_C965555.pdf" H 7400 3675 50  0001 L TNN
+F 4 "C965555" H 7300 4050 50  0001 C CNN "LCSC"
 F 5 "-" H 7300 4050 50  0001 C CNN "Mouser"
 F 6 "" H 7300 4050 50  0001 C CNN "Price"
@@
 AR Path="/612408B6/6035A383" Ref="R67"  Part="1"
 F 0 "R67" V 2000 3950 50  0000 C CNN
-F 1 "220" V 2100 3950 50  0000 C CNN
+F 1 "470" V 2200 3950 50  0000 C CNN
 F 2 "Resistor_SMD:R_0603_1608Metric" H 2100 3950 50  0001 C CNN
 F 3 "~" H 2100 3950 50  0001 C CNN
@@
 	0    1    1    0
 $EndComp
-$Comp
-L Device:R_Small R?
-U 1 1 6035C296
-P 2100 4150
-AR Path="/6035C296" Ref="R?"  Part="1"
-AR Path="/612408B6/6035C296" Ref="R68"  Part="1"
-F 0 "R68" V 2000 4150 50  0000 C CNN
-F 1 "220" V 2100 4150 50  0000 C CNN
-F 2 "Resistor_SMD:R_0603_1608Metric" H 2100 4150 50  0001 C CNN
-F 3 "~" H 2100 4150 50  0001 C CNN
-F 4 "" H 2100 4150 50  0001 C CNN "Price"
-F 5 "C269696" H 2100 4150 50  0001 C CNN "LCSC"
-F 6 "-" H 2100 4150 50  0001 C CNN "Mouser"
-F 7 "N" H 2100 4150 50  0001 C CNN "Sponsored"
-	1    2100 4150
-	0    1    1    0
-$EndComp
 Wire Wire Line
 	2200 3950 2250 3950
 Wire Wire Line
 	2250 3950 2250 4050
-Wire Wire Line
-	2250 4050 2250 4150
-Wire Wire Line
-	2250 4150 2200 4150
-Connection ~ 2250 4050
 Text HLabel 2000 4150 0    79   Input ~ 0
 DATA_IN2
 Text GLabel 3150 3650 1    39   Input ~ 0
 PWR_LED
+Wire Wire Line
+	2000 4150 2250 4150
+Wire Wire Line
+	2250 4150 2250 4050
+Connection ~ 2250 4050
 $EndSCHEMATC

Commit message: Update artwork
Parts:
- D4, D5, D6, D7, D8, D9: value WS2812B-2020 -> SK6812-EC15; footprint custom:ws2812-2020 -> LED_SMD:LED_SK6812_EC15_1.5x1.5mm; LCSC C965555 -> (none)
Changed lines of the file:
@@
 P 4300 4050
 F 0 "D4" H 4100 4300 50  0000 L CNN
-F 1 "WS2812B-2020" V 4450 4300 50  0000 L CNN
-F 2 "custom:ws2812-2020" H 4350 3750 50  0001 L TNN
-F 3 "https://datasheet.lcsc.com/szlcsc/2012110135_Worldsemi-WS2812B-2020_C965555.pdf" H 4400 3675 50  0001 L TNN
-F 4 "C965555" H 4300 4050 50  0001 C CNN "LCSC"
+F 1 "SK6812-EC15" V 4450 4300 50  0000 L CNN
+F 2 "LED_SMD:LED_SK6812_EC15_1.5x1.5mm" H 4350 3750 50  0001 L TNN
+F 3 "http://www.normandled.com/Product/view/id/842.html" H 4400 3675 50  0001 L TNN
+F 4 "" H 4300 4050 50  0001 C CNN "LCSC"
 F 5 "-" H 4300 4050 50  0001 C CNN "Mouser"
 F 6 "" H 4300 4050 50  0001 C CNN "Price"
@@
 P 4900 4050
 F 0 "D5" H 4700 4300 50  0000 L CNN
-F 1 "WS2812B-2020" V 5050 4300 50  0000 L CNN
-F 2 "custom:ws2812-2020" H 4950 3750 50  0001 L TNN
-F 3 "https://datasheet.lcsc.com/szlcsc/2012110135_Worldsemi-WS2812B-2020_C965555.pdf" H 5000 3675 50  0001 L TNN
-F 4 "C965555" H 4900 4050 50  0001 C CNN "LCSC"
+F 1 "SK6812-EC15" V 5050 4300 50  0000 L CNN
+F 2 "LED_SMD:LED_SK6812_EC15_1.5x1.5mm" H 4950 3750 50  0001 L TNN
+F 3 "http://www.normandled.com/Product/view/id/842.html" H 5000 3675 50  0001 L TNN
+F 4 "" H 4900 4050 50  0001 C CNN "LCSC"
 F 5 "-" H 4900 4050 50  0001 C CNN "Mouser"
 F 6 "" H 4900 4050 50  0001 C CNN "Price"
@@
 P 5500 4050
 F 0 "D6" H 5300 4300 50  0000 L CNN
-F 1 "WS2812B-2020" V 5650 4300 50  0000 L CNN
-F 2 "custom:ws2812-2020" H 5550 3750 50  0001 L TNN
-F 3 "https://datasheet.lcsc.com/szlcsc/2012110135_Worldsemi-WS2812B-2020_C965555.pdf" H 5600 3675 50  0001 L TNN
-F 4 "C965555" H 5500 4050 50  0001 C CNN "LCSC"
+F 1 "SK6812-EC15" V 5650 4300 50  0000 L CNN
+F 2 "LED_SMD:LED_SK6812_EC15_1.5x1.5mm" H 5550 3750 50  0001 L TNN
+F 3 "http://www.normandled.com/Product/view/id/842.html" H 5600 3675 50  0001 L TNN
+F 4 "" H 5500 4050 50  0001 C CNN "LCSC"
 F 5 "-" H 5500 4050 50  0001 C CNN "Mouser"
 F 6 "" H 5500 4050 50  0001 C CNN "Price"
@@
 P 6100 4050
 F 0 "D7" H 5900 4300 50  0000 L CNN
-F 1 "WS2812B-2020" V 6250 4300 50  0000 L CNN
-F 2 "custom:ws2812-2020" H 6150 3750 50  0001 L TNN
-F 3 "https://datasheet.lcsc.com/szlcsc/2012110135_Worldsemi-WS2812B-2020_C965555.pdf" H 6200 3675 50  0001 L TNN
-F 4 "C965555" H 6100 4050 50  0001 C CNN "LCSC"
+F 1 "SK6812-EC15" V 6250 4300 50  0000 L CNN
+F 2 "LED_SMD:LED_SK6812_EC15_1.5x1.5mm" H 6150 3750 50  0001 L TNN
+F 3 "http://www.normandled.com/Product/view/id/842.html" H 6200 3675 50  0001 L TNN
+F 4 "" H 6100 4050 50  0001 C CNN "LCSC"
 F 5 "-" H 6100 4050 50  0001 C CNN "Mouser"
 F 6 "" H 6100 4050 50  0001 C CNN "Price"
@@
 P 6700 4050
 F 0 "D8" H 6500 4300 50  0000 L CNN
-F 1 "WS2812B-2020" V 6850 4300 50  0000 L CNN
-F 2 "custom:ws2812-2020" H 6750 3750 50  0001 L TNN
-F 3 "https://datasheet.lcsc.com/szlcsc/2012110135_Worldsemi-WS2812B-2020_C965555.pdf" H 6800 3675 50  0001 L TNN
-F 4 "C965555" H 6700 4050 50  0001 C CNN "LCSC"
+F 1 "SK6812-EC15" V 6850 4300 50  0000 L CNN
+F 2 "LED_SMD:LED_SK6812_EC15_1.5x1.5mm" H 6750 3750 50  0001 L TNN
+F 3 "http://www.normandled.com/Product/view/id/842.html" H 6800 3675 50  0001 L TNN
+F 4 "" H 6700 4050 50  0001 C CNN "LCSC"
 F 5 "-" H 6700 4050 50  0001 C CNN "Mouser"
 F 6 "" H 6700 4050 50  0001 C CNN "Price"
@@
 P 7300 4050
 F 0 "D9" H 7100 4300 50  0000 L CNN
-F 1 "WS2812B-2020" V 7450 4300 50  0000 L CNN
-F 2 "custom:ws2812-2020" H 7350 3750 50  0001 L TNN
-F 3 "https://datasheet.lcsc.com/szlcsc/2012110135_Worldsemi-WS2812B-2020_C965555.pdf" H 7400 3675 50  0001 L TNN
-F 4 "C965555" H 7300 4050 50  0001 C CNN "LCSC"
+F 1 "SK6812-EC15" V 7450 4300 50  0000 L CNN
+F 2 "LED_SMD:LED_SK6812_EC15_1.5x1.5mm" H 7350 3750 50  0001 L TNN
+F 3 "http://www.normandled.com/Product/view/id/842.html" H 7400 3675 50  0001 L TNN
+F 4 "" H 7300 4050 50  0001 C CNN "LCSC"
 F 5 "-" H 7300 4050 50  0001 C CNN "Mouser"
 F 6 "" H 7300 4050 50  0001 C CNN "Price"

Commit message: First steps of routing prototype 2, switch to 0402 for most passives
Parts:
- C21, C22, C23: footprint Capacitor_SMD:C_0603_1608Metric -> Capacitor_SMD:C_0402_1005Metric; LCSC C26413 -> C107372
- R67: footprint Resistor_SMD:R_0603_1608Metric -> Resistor_SMD:R_0402_1005Metric; LCSC C269696 -> (none)
Changed lines of the file:
@@
 F 0 "C21" H 10365 6146 50  0000 L CNN
 F 1 "1u" H 10365 6055 50  0000 L CNN
-F 2 "Capacitor_SMD:C_0603_1608Metric" H 10288 5950 50  0001 C CNN
-F 3 "~" H 10250 6100 50  0001 C CNN
+F 2 "Capacitor_SMD:C_0402_1005Metric" H 10288 5950 50  0001 C CNN
+F 3 "" H 10250 6100 50  0001 C CNN
 F 4 "" H 10250 6100 50  0001 C CNN "Price"
 F 5 "N" H 10250 6100 50  0001 C CNN "Sponsored"
-F 6 "C26413" H 10250 6100 50  0001 C CNN "LCSC"
+F 6 "C107372" H 10250 6100 50  0001 C CNN "LCSC"
 	1    10250 6100
 	-1   0    0    -1
@@
 F 0 "C22" H 10715 6146 50  0000 L CNN
 F 1 "1u" H 10715 6055 50  0000 L CNN
-F 2 "Capacitor_SMD:C_0603_1608Metric" H 10638 5950 50  0001 C CNN
-F 3 "~" H 10600 6100 50  0001 C CNN
+F 2 "Capacitor_SMD:C_0402_1005Metric" H 10638 5950 50  0001 C CNN
+F 3 "" H 10600 6100 50  0001 C CNN
 F 4 "" H 10600 6100 50  0001 C CNN "Price"
 F 5 "N" H 10600 6100 50  0001 C CNN "Sponsored"
-F 6 "C26413" H 10600 6100 50  0001 C CNN "LCSC"
+F 6 "C107372" H 10600 6100 50  0001 C CNN "LCSC"
 	1    10600 6100
 	-1   0    0    -1
@@
 F 0 "C23" H 11065 6146 50  0000 L CNN
 F 1 "1u" H 11065 6055 50  0000 L CNN
-F 2 "Capacitor_SMD:C_0603_1608Metric" H 10988 5950 50  0001 C CNN
-F 3 "~" H 10950 6100 50  0001 C CNN
+F 2 "Capacitor_SMD:C_0402_1005Metric" H 10988 5950 50  0001 C CNN
+F 3 "" H 10950 6100 50  0001 C CNN
 F 4 "" H 10950 6100 50  0001 C CNN "Price"
 F 5 "N" H 10950 6100 50  0001 C CNN "Sponsored"
-F 6 "C26413" H 10950 6100 50  0001 C CNN "LCSC"
+F 6 "C107372" H 10950 6100 50  0001 C CNN "LCSC"
 	1    10950 6100
 	-1   0    0    -1
@@
 F 0 "R67" V 2000 3950 50  0000 C CNN
 F 1 "470" V 2200 3950 50  0000 C CNN
-F 2 "Resistor_SMD:R_0603_1608Metric" H 2100 3950 50  0001 C CNN
+F 2 "Resistor_SMD:R_0402_1005Metric" H 2100 3950 50  0001 C CNN
 F 3 "~" H 2100 3950 50  0001 C CNN
 F 4 "" H 2100 3950 50  0001 C CNN "Price"
-F 5 "C269696" H 2100 3950 50  0001 C CNN "LCSC"
+F 5 "" H 2100 3950 50  0001 C CNN "LCSC"
 F 6 "-" H 2100 3950 50  0001 C CNN "Mouser"
 F 7 "N" H 2100 3950 50  0001 C CNN "Sponsored"

Commit message: Some more work
Parts:
- renumbered C21 to C31, C22 to C32, C23 to C33, D4 to D3, D5 to D4, D6 to D5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
Changed lines of the file:
@@
 $EndDescr
 $Comp
-L LED:WS2812B D4
+L LED:WS2812B D3
 U 1 1 5F7D8169
 P 4300 4050
-F 0 "D4" H 4100 4300 50  0000 L CNN
+F 0 "D3" H 4100 4300 50  0000 L CNN
 F 1 "SK6812-EC15" V 4450 4300 50  0000 L CNN
 F 2 "LED_SMD:LED_SK6812_EC15_1.5x1.5mm" H 4350 3750 50  0001 L TNN
@@
 $EndComp
 $Comp
-L power:GND #PWR095
+L power:GND #PWR0144
 U 1 1 612C7A49
 P 4300 4350
-F 0 "#PWR095" H 4300 4100 50  0001 C CNN
+F 0 "#PWR0144" H 4300 4100 50  0001 C CNN
 F 1 "GND" H 4305 4177 50  0000 C CNN
 F 2 "" H 4300 4350 50  0001 C CNN
@@
 PWR_LED
 $Comp
-L LED:WS2812B D5
+L LED:WS2812B D4
 U 1 1 612CEAF2
 P 4900 4050
-F 0 "D5" H 4700 4300 50  0000 L CNN
+F 0 "D4" H 4700 4300 50  0000 L CNN
 F 1 "SK6812-EC15" V 5050 4300 50  0000 L CNN
 F 2 "LED_SMD:LED_SK6812_EC15_1.5x1.5mm" H 4950 3750 50  0001 L TNN
@@
 $EndComp
 $Comp
-L power:GND #PWR096
+L power:GND #PWR0145
 U 1 1 612CEAF8
 P 4900 4350
-F 0 "#PWR096" H 4900 4100 50  0001 C CNN
+F 0 "#PWR0145" H 4900 4100 50  0001 C CNN
 F 1 "GND" H 4905 4177 50  0000 C CNN
 F 2 "" H 4900 4350 50  0001 C CNN
@@
 PWR_LED
 $Comp
-L LED:WS2812B D6
+L LED:WS2812B D5
 U 1 1 612CEE91
 P 5500 4050
-F 0 "D6" H 5300 4300 50  0000 L CNN
+F 0 "D5" H 5300 4300 50  0000 L CNN
 F 1 "SK6812-EC15" V 5650 4300 50  0000 L CNN
 F 2 "LED_SMD:LED_SK6812_EC15_1.5x1.5mm" H 5550 3750 50  0001 L TNN
@@
 $EndComp
 $Comp
-L power:GND #PWR097
+L power:GND #PWR0146
 U 1 1 612CEE97
 P 5500 4350
-F 0 "#PWR097" H 5500 4100 50  0001 C CNN
+F 0 "#PWR0146" H 5500 4100 50  0001 C CNN
 F 1 "GND" H 5505 4177 50  0000 C CNN
 F 2 "" H 5500 4350 50  0001 C CNN
@@
 PWR_LED
 $Comp
-L LED:WS2812B D7
+L LED:WS2812B D6
 U 1 1 612CF6E4
 P 6100 4050
-F 0 "D7" H 5900 4300 50  0000 L CNN
+F 0 "D6" H 5900 4300 50  0000 L CNN
 F 1 "SK6812-EC15" V 6250 4300 50  0000 L CNN
 F 2 "LED_SMD:LED_SK6812_EC15_1.5x1.5mm" H 6150 3750 50  0001 L TNN
@@
 $EndComp
 $Comp
-L power:GND #PWR098
+L power:GND #PWR0147
 U 1 1 612CF6EA
 P 6100 4350
-F 0 "#PWR098" H 6100 4100 50  0001 C CNN
+F 0 "#PWR0147" H 6100 4100 50  0001 C CNN
 F 1 "GND" H 6105 4177 50  0000 C CNN
 F 2 "" H 6100 4350 50  0001 C CNN
@@
 PWR_LED
 $Comp
-L LED:WS2812B D8
+L LED:WS2812B D7
 U 1 1 612CFE55
 P 6700 4050
-F 0 "D8" H 6500 4300 50  0000 L CNN
+F 0 "D7" H 6500 4300 50  0000 L CNN
 F 1 "SK6812-EC15" V 6850 4300 50  0000 L CNN
 F 2 "LED_SMD:LED_SK6812_EC15_1.5x1.5mm" H 6750 3750 50  0001 L TNN
@@
 $EndComp
 $Comp
-L power:GND #PWR099
+L power:GND #PWR0148
 U 1 1 612CFE5B
 P 6700 4350
-F 0 "#PWR099" H 6700 4100 50  0001 C CNN
+F 0 "#PWR0148" H 6700 4100 50  0001 C CNN
 F 1 "GND" H 6705 4177 50  0000 C CNN
 F 2 "" H 6700 4350 50  0001 C CNN
@@
 PWR_LED
 $Comp
-L LED:WS2812B D9
+L LED:WS2812B D8
 U 1 1 612D0799
 P 7300 4050
-F 0 "D9" H 7100 4300 50  0000 L CNN
+F 0 "D8" H 7100 4300 50  0000 L CNN
 F 1 "SK6812-EC15" V 7450 4300 50  0000 L CNN
 F 2 "LED_SMD:LED_SK6812_EC15_1.5x1.5mm" H 7350 3750 50  0001 L TNN
@@
 $EndComp
 $Comp
-L power:GND #PWR0100
+L power:GND #PWR0149
 U 1 1 612D079F
 P 7300 4350
-F 0 "#PWR0100" H 7300 4100 50  0001 C CNN
+F 0 "#PWR0149" H 7300 4100 50  0001 C CNN
 F 1 "GND" H 7305 4177 50  0000 C CNN
 F 2 "" H 7300 4350 50  0001 C CNN
@@
 PWR_LED
 $Comp
-L Device:C C21
+L Device:C C31
 U 1 1 612D0DFB
 P 10250 6100
-F 0 "C21" H 10365 6146 50  0000 L CNN
+F 0 "C31" H 10365 6146 50  0000 L CNN
 F 1 "1u" H 10365 6055 50  0000 L CNN
 F 2 "Capacitor_SMD:C_0402_1005Metric" H 10288 5950 50  0001 C CNN
@@
 $EndComp
 $Comp
-L power:GND #PWR0101
+L power:GND #PWR0150
 U 1 1 612D0F05
 P 10250 6250
-F 0 "#PWR0101" H 10250 6000 50  0001 C CNN
+F 0 "#PWR0150" H 10250 6000 50  0001 C CNN
 F 1 "GND" H 10255 6077 50  0000 C CNN
 F 2 "" H 10250 6250 50  0001 C CNN
@@
 PWR_LED
 $Comp
-L Device:C C22
+L Device:C C32
 U 1 1 612D2985
 P 10600 6100
-F 0 "C22" H 10715 6146 50  0000 L CNN
+F 0 "C32" H 10715 6146 50  0000 L CNN
 F 1 "1u" H 10715 6055 50  0000 L CNN
 F 2 "Capacitor_SMD:C_0402_1005Metric" H 10638 5950 50  0001 C CNN
@@
 $EndComp
 $Comp
-L power:GND #PWR0102
+L power:GND #PWR0151
 U 1 1 612D298B
 P 10600 6250
-F 0 "#PWR0102" H 10600 6000 50  0001 C CNN
+F 0 "#PWR0151" H 10600 6000 50  0001 C CNN
 F 1 "GND" H 10605 6077 50  0000 C CNN
 F 2 "" H 10600 6250 50  0001 C CNN
@@
 PWR_LED
 $Comp
-L Device:C C23
+L Device:C C33
 U 1 1 612D3CA5
 P 10950 6100
-F 0 "C23" H 11065 6146 50  0000 L CNN
+F 0 "C33" H 11065 6146 50  0000 L CNN
 F 1 "1u" H 11065 6055 50  0000 L CNN
 F 2 "Capacitor_SMD:C_0402_1005Metric" H 10988 5950 50  0001 C CNN
@@
 $EndComp
 $Comp
-L power:GND #PWR0103
+L power:GND #PWR0152
 U 1 1 612D3CAB
 P 10950 6250
-F 0 "#PWR0103" H 10950 6000 50  0001 C CNN
+F 0 "#PWR0152" H 10950 6000 50  0001 C CNN
 F 1 "GND" H 10955 6077 50  0000 C CNN
 F 2 "" H 10950 6250 50  0001 C CNN
@@
 P 2800 4350
 AR Path="/5F51E414/60345F64" Ref="#PWR?"  Part="1"
-AR Path="/612408B6/60345F64" Ref="#PWR0211"  Part="1"
-F 0 "#PWR0211" H 2800 4100 50  0001 C CNN
+AR Path="/612408B6/60345F64" Ref="#PWR0142"  Part="1"
+F 0 "#PWR0142" H 2800 4100 50  0001 C CNN
 F 1 "GND" H 2805 4177 50  0000 C CNN
 F 2 "" H 2800 4350 50  0001 C CNN
@@
 P 3150 4350
 AR Path="/5F51E414/60345F44" Ref="#PWR?"  Part="1"
-AR Path="/612408B6/60345F44" Ref="#PWR0213"  Part="1"
-F 0 "#PWR0213" H 3150 4100 50  0001 C CNN
+AR Path="/612408B6/60345F44" Ref="#PWR0143"  Part="1"
+F 0 "#PWR0143" H 3150 4100 50  0001 C CNN
 F 1 "GND" H 3155 4177 50  0000 C CNN
 F 2 "" H 3150 4350 50  0001 C CNN
@@
 P 2100 3950
 AR Path="/6035A383" Ref="R?"  Part="1"
-AR Path="/612408B6/6035A383" Ref="R67"  Part="1"
-F 0 "R67" V 2000 3950 50  0000 C CNN
+AR Path="/612408B6/6035A383" Ref="R50"  Part="1"
+F 0 "R50" V 2000 3950 50  0000 C CNN
 F 1 "470" V 2200 3950 50  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 2100 3950 50  0001 C CNN
