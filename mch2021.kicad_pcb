# Repository badgeteam/mch2022-badge-hardware

File README.md:

# MCH2022 badge hardware

The hardware design files for the MCH2022 event badge.

## Documentation

Detailed information can be found on our website at https://badge.team/docs/badges/mch2022/.

Need the schematic? [It's in this repository as a PDF file](schematic.pdf).

## Firmware

There are multiple processors on this board, the firmware flashed on to the board in the factory can be found in the following repositories:

 - https://github.com/badgeteam/mch2022-firmware-esp32
 - https://github.com/badgeteam/mch2022-firmware-rp2040

## License

This hardware design may be used under the terms of the [CERN-OHL-P](LICENSE) license.

## Authors

The artwork featured in this hardware design has been designed by Nikolett S. from [tilde.industries](https://tilde.industries).

The electronics have been designed by Renze Nicolai from [Nicolai Electronics](https://nicolaielectronics.nl).

A special thanks to all who contributed by helping with the routing and by debugging the hardware design:

 - Anne Jan Brouwer
 - Kliment Yanev
 - Kuristian
 - Martin Ling
 - Paul Honig
 - Sylvain Munaut
 - Tom Clement
 - Fuchsia (f0x)
 - Sander de Haan

## KiCad design mch2021.kicad_pcb

Board: 4 copper layers, 144.8 x 94.3 mm, 218 parts (201 on the bottom side), 165 nets.

Parts:
BT1: LiPo; JST_PH_S3B-PH-SM4-TB_1x03-1MP_P2.00mm_Horizontal
C1, C5, C7, C11, C31, C32, C33, C53, C55, C56: 1u; C_0402_1005Metric
C2, C6, C8, C12, C13, C14, C15, C16, C18, C19, C20, C21, C22, C23, C24, C26, C27, C30, C37, C47, C48, C50, C54, C57, C58, C59, C60, C61, C62, C63: 100n; C_0402_1005Metric
C3, C4: 2.2u; C_0402_1005Metric
C9, C10, C28, C29, C40, C41: 22p; C_0402_1005Metric
C17, C25, C34, C42: 10u; C_0402_1005Metric
C35, C36: DNP; C_0402_1005Metric
C38, C39, C43, C44, C45, C46, C49: 22u; C_0805_2012Metric
C51, C52: 2.2n; C_0402_1005Metric
D1: USBLC6-4SC6; SOT23-6L
D2: RGB-5050; LED_RGB_5050-6
D3, D4, D5, D6, D7: SK6805-EC15; LED_SK6805_EC15_1.5x1.5mm
D9: NSVR0320MW2T1G; D_SOD-323
F1: 1A; Fuse_0805_2012Metric
J1: AudioJack3; Boom-audiojack-PJ-320B
J2: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J3, J6: QWIIC_CONNECTORJS-1MM; 1X04_1MM_RA_GND
J4: PMOD; PinSocket_2x06_P2.54mm_Horizontal
J5: Micro SD card; MicroSD-SOFNG-TF-002-H18
J7: LCD; Hirose_FH12-40S-0.5SH_1x40-1MP_P0.50mm_Horizontal
J9, J11: CONN-7; 1x7_smd_row
J10: CONN-3; 1x3_smd_row
J12: Hook 1; TestPoint_Keystone_5019_Minature
J13: Hook 2; TestPoint_Keystone_5019_Minature
L3, L4: 2.2u; Inductor_MSC20FC
N1, N5: Logo; badgeteam
N2: Artwork; vector7
N3: May Contain Hardware; protoboard-squares
N4: More Cool Hardware; protoboard-squares-big
Q1, Q2, Q4, Q5: Q_NMOS_GSD; SOT-23
R1, R2: 5k1; R_0402_1005Metric
R3, R4, R5, R73, R74: 470; R_0402_1005Metric
R6, R7: 27; R_0402_1005Metric
R8, R9, R10, R11, R22, R26, R31, R35, R36, R37, R38, R50, R54, R55, R57, R58, R61, R63, R64, R65, R67, R75, R76, R77: 10k; R_0402_1005Metric
R12, R13, R14, R15, R23, R24, R27, R33: 47; R_0402_1005Metric
R16, R17, R18, R19, R20, R21, R28, R53, R59: 100k; R_0402_1005Metric
R30, R34, R47, R48, R49: 4k7; R_0402_1005Metric
R32, R41, R69, R70: DNP; R_0402_1005Metric
R39, R42, R60: 45.3k; R_0402_1005Metric
R40, R43, R44, R45, R46: 4.7k; R_0402_1005Metric
R51, R52, R71, R72: 0; R_0402_1005Metric
R56, R62: 2k; R_0402_1005Metric
R68: 3.4k; R_0402_1005Metric
RN1, RN4, RN5: 47; R_Array_Convex_4x0603
RN2, RN3, RN6: 100k; R_Array_Convex_4x0603
S1: JS1400BFQ; SW_JS1400BFQ
SW1: Start; 1TS009
SW2: Select; 1TS009
SW3: Menu; 1TS009
SW4: Home; 1TS009
SW5: B; 1TS009
SW6: A; 1TS009
SW7: Power switch; SW_SPDT_PCM12
TP1, TP9, TP12, TP13, TP14: LED OUT; TestPoint_Pad_1.0x1.0mm
TP2: LED_DATA_BUFF; TestPoint_Pad_1.0x1.0mm
TP3: LED_DATA; TestPoint_Pad_1.0x1.0mm
TP4: LCD MODE; TestPoint_Pad_1.0x1.0mm
TP5: LCD RESET; TestPoint_Pad_1.0x1.0mm
TP6: LCD BACKLIGHT; TestPoint_Pad_1.0x1.0mm
TP7: FPGA RX; TestPoint_Pad_1.0x1.0mm
TP8: FPGA TX; TestPoint_Pad_1.0x1.0mm
TP10: STM32 RESET; TestPoint_Pad_1.0x1.0mm
TP11: STM32 BOOT0; TestPoint_Pad_1.0x1.0mm
TP15: BL; TestPoint_Pad_1.0x1.0mm
U1: PCM5100; TSSOP-20_4.4x6.5mm_P0.65mm
U2, U10: 74LVC1G125; SOT-353_SC-70-5
U3: RP2040; QFN40P700X700X90-57N
U4: PCA9555PW; TSSOP-24_4.4x7.8mm_P0.65mm
U5: ICE40UP5K-SG48ITR; QFN-48-1EP_7x7mm_P0.5mm_EP5.6x5.6mm
U6: LY68L6400; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.41x3.81mm
U7: ESP32-WROVER
U8: BNO055; LGA-28_5.2x3.8mm_BNO0055
U9: BME680; Bosch_LGA-8_3x3mm_P0.8mm_ClockwisePinNumbering
U11, U12: SY8079AAC; SOT-23-5
U13: XT4054K421MR-G; SOT-23-5
U14, U15, U16: SY6280AAC; SOT-23-5
X1: Simple_Addon_v2; Simple_Addon_v2-BADGE-2x3-nosilk
Y2: 12MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm
Y3: 32kHz; Crystal_SMD_3215-2Pin_3.2x1.5mm

Connections:
+1V1: C7.1, C8.1, C58.1, U3.23, U3.45, U3.50
+1V2: C15.1, C16.1, C41.1, C44.1, C46.1, L4.1, R33.1, R61.1, U5.5, U5.30
+3V3: C5.1, C6.1, C11.1, C12.1, C13.1, C14.1, C19.1, C20.1, C21.1, C22.1, C24.1, C25.1, C26.1, C30.1, C40.1, C43.1, C45.1, C47.1, C53.1, C54.1, C59.1, C60.1, C61.1, C62.1, C63.1, D2.1, D2.2, D2.3, J3.2, J4.11, J4.12, J6.2, J7.6, J7.7, J7.12, J7.33, J9.1, J11.1, L3.1, R16.1, R17.1, R18.1, R19.1, R22.2, R26.1, R28.1, R30.1, R32.1, R34.1, R35.1, R36.1, R37.1, R38.1, R41.1, R43.1, R44.1, R45.1, R46.1, R47.1, R48.1, R49.1, R60.1, R62.2, R76.1, U1.1, U1.8, U1.17, U1.20, U2.5, U3.1, U3.10, U3.22, U3.33, U3.42, U3.43, U3.44, U3.48, U3.49, U4.2, U4.3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
/BOSCH/BNO055_CAP: C27.1, U8.9
/BOSCH/BNO055_XIN32: C28.1, U8.27, Y3.2
/BOSCH/BNO055_XOUT32: C29.1, U8.26, Y3.1
/BOSCH/INT: R49.2, U7.4, U8.14
/BUTTONS/BNO055_RESET: R47.2, U4.8, U8.11
/BUTTONS/BTN_ACCEPT: SW6.1, U4.20
/BUTTONS/BTN_BACK: SW5.1, U4.19
/BUTTONS/BTN_HOME: SW4.1, U4.13
/BUTTONS/BTN_MENU: SW3.1, U4.11
/BUTTONS/BTN_SELECT: SW2.1, U4.10
/BUTTONS/BTN_START: SW1.1, U4.9
/BUTTONS/FPGA_CDONE: R32.2, U4.7, U5.7
/BUTTONS/FPGA_RESET: R31.1, U4.6, U5.8
/BUTTONS/I2C_SCL: J3.4, J11.7, R43.2, U3.5, U4.22, U7.33, U8.19, U9.4
/BUTTONS/I2C_SDA: J3.3, J11.6, R44.2, U3.4, U4.23, U7.36, U8.20, U9.3
/BUTTONS/RP2040_BOOT: R24.2, TP11.1, U4.5
/CC1: D1.3, J2.A5, R1.2, R27.2
/CC2: J2.B5, R2.2
/ESP32/ESP32_BL: R23.1, R38.2, U7.25
/ESP32/ESP32_EN: C23.1, R37.2, U3.16, U7.3
/ESP32/ESP32_RX: U3.2, U7.34
/ESP32/ESP32_TX: U3.3, U7.35
/ESP32/LCD_DC: R13.2, U7.9
/ESP32/SPI_CLK: U2.2, U3.29, U5.15, U7.30
/ESP32/SPI_MISO: U3.30, U5.14, U7.7
/ESP32/SPI_MOSI: J7.13, U3.31, U5.17, U7.37
/FPGA/IRQ: R34.2, U5.10, U7.5
/FPGA/LCD_D0: J7.25, RN2.8, U5.26
/FPGA/LCD_D1: J7.26, RN2.7, U5.27
/FPGA/LCD_D2: J7.27, RN2.6, U5.31
/FPGA/LCD_D3: J7.28, RN2.5, U5.32
/FPGA/LCD_D4: J7.29, RN3.8, U5.34
/FPGA/LCD_D5: J7.30, RN3.7, U5.37
/FPGA/LCD_D6: J7.31, RN3.6, U5.38
/FPGA/LCD_D7: J7.32, RN3.5, U5.42
/FPGA/LCD_RS: R12.2, U5.11
/FPGA/LCD_WR: R14.2, U5.23
/FPGA/PMOD_1: J4.2, RN4.2
/FPGA/PMOD_1i: RN4.7, U5.47
/FPGA/PMOD_2: J4.4, RN4.3
/FPGA/PMOD_2i: RN4.6, U5.48
/FPGA/PMOD_3: J4.6, RN5.2
/FPGA/PMOD_3i: RN5.7, U5.4
/FPGA/PMOD_4: J4.8, RN5.4
/FPGA/PMOD_4i: RN5.5, U5.2
/FPGA/PMOD_7: J4.1, RN4.1
/FPGA/PMOD_7i: RN4.8, U5.44
/FPGA/PMOD_8: J4.3, RN4.4
/FPGA/PMOD_8i: RN4.5, U5.45
/FPGA/PMOD_9: J4.5, RN5.1
/FPGA/PMOD_9i: RN5.8, U5.3
/FPGA/PMOD_10: J4.7, RN5.3
/FPGA/PMOD_10i: RN5.6, U5.46
/FPGA/RGB0: D2.4, U5.39
/FPGA/RGB1: D2.5, U5.40
/FPGA/RGB2: D2.6, U5.41
/FPGA/SPI_CS: R35.2, U5.16, U7.12
/FPGA/VCCPLL: C17.1, C18.1, R33.2, U5.29
/LCD/BACKLIGHT: R16.2, RN1.4, TP6.1, U3.18
/LCD/CS: J7.9, R18.2, U7.8
/LCD/FMARK: J7.8, U5.25
/LCD/LCD_IM0: J7.38, Q2.1, R15.1, R20.2, U2.1
/LCD/LCD_K0: J7.34, RN1.1
/LCD/LCD_K1: J7.35, RN1.2
/LCD/LCD_K2: J7.36, RN1.3
/LCD/LCD_RS_SCK: J7.10, R12.1, U2.4
/LCD/LCD_WR_RS: J7.11, R13.1, R14.1, R21.2
/LED/DATA_IN: TP3.1, U3.14, U10.2
/LED/DATA_OUT: D7.3, TP1.1
/LED/LED1_DATA: D3.1, TP2.1, U10.4
/LED/LED2_DATA: D3.3, D4.1
/LED/LED3_DATA: D4.3, D5.1
/LED/LED4_DATA: D5.3, D6.1
/LED/LED5_DATA: D6.3, D7.1
/PCM5100_CAPN: C3.2, U1.4
/PCM5100_CAPP: C3.1, U1.2
/PCM5100_LDOO: C1.1, C2.1, U1.18
/PCM5100_OUTL: R73.1, U1.6
/PCM5100_OUTR: R74.1, U1.7
/PCM5100_VNEG: C4.1, U1.5
/POWER/1V2REG_VIN: C36.1, C39.1, R52.1, U12.1, U12.4
/POWER/3V3REG_VIN: C35.1, C38.1, R51.1, U11.1, U11.4
/POWER/BATT_TEMP: BT1.1, R76.2, U3.39
/POWER/CHARGING: R62.1, U3.35, U13.1
/POWER/FB12: C41.2, R58.1, R61.2, U12.5
/POWER/FB33: C40.2, R57.1, R60.2, U11.5
/POWER/PWR_LED_ENABLE: R65.2, U3.34, U16.4
/POWER/PWR_SDCARD_ENABLE: R64.2, U7.29, U15.4
/POWER/SENSE_VBAT: C50.1, RN6.7, RN6.8, U3.40
/POWER/SENSE_VUSB: C48.1, RN6.5, RN6.6, U3.41
/POWER/SW12: L4.2, U12.3
/POWER/SW33: L3.2, U11.3
/RP2040/ESP32_WK: R30.2, U3.17, U4.1, U7.6
/RP2040/FPGA_RX: TP7.1, U3.36, U5.6
/RP2040/FPGA_TX: TP8.1, U3.37, U5.9
/RP2040/LCD_MODE: R15.2, TP4.1, U3.28
/RP2040/LCD_RESET: J7.15, R19.2, TP5.1, U3.27
/RP2040/SPI_CS: R28.2, U3.32, U7.31
/USB_D+: D1.6, J2.A6, J2.B6, R7.2
/USB_D-: D1.4, J2.A7, J2.B7, R6.1
/USB_VBUS: D1.5, F1.2, J2.A4, J2.A9, J2.B4, J2.B9
ARTWORK: C57.1, R75.2
AUDIO_L: J1.T, J9.7, R69.2, R71.2
AUDIO_R: J1.R, J9.6, R70.2, R72.2
ESP_I2S_CLK: R5.2, R40.1, U1.13, U7.14
ESP_I2S_DATA: R4.2, U1.14, U7.16
ESP_I2S_LR: R3.2, U1.15, U7.26
EXT_SCL: J6.4, J9.5, J11.5, R45.2, U3.12, U7.10, X1.4
EXT_SDA: J6.3, J9.4, J11.4, R46.2, U3.11, U7.11, X1.3
FPGA_I2S_CLK: R5.1, U5.28
FPGA_I2S_DATA: R4.1, U5.36
FPGA_I2S_LR: R3.1, U5.43
GND: BT1.2, C1.2, C2.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.1, C35.2, C36.2, C37.1, C38.2, C39.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C61.2, C62.2, C63.2, D1.2, D3.4, D4.4, D5.4, D6.4, D7.4, J1.S, J2.A1, J2.A12, J2.B1, J2.B12, J2.S1, J3.1, J3.5, J3.6, J4.9, J4.10, J5.6, J5.9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
JOY_A: S1.1, U4.14
JOY_B: S1.2, U4.15
JOY_C: S1.3, U4.16
JOY_D: S1.4, U4.17
JOY_E: S1.6, U4.18
unnamed: C9.1, U3.21, Y2.3
unnamed: C10.1, U3.20, Y2.1
unnamed: C51.1, R72.1, R74.2
unnamed: C52.1, R71.1, R73.2
unnamed: J5.1, R77.2
unnamed: J5.2, R50.2
unnamed: J5.8, R8.2
unnamed: J7.39, J7.40, Q2.3, R17.2
unnamed: Q1.1, RN1.5
unnamed: Q1.3, RN1.6, RN1.7, RN1.8
unnamed: Q4.1, R55.2
unnamed: Q4.3, R54.2, R59.2, U14.4
unnamed: Q5.1, R27.1
unnamed: Q5.3, R22.1
unnamed: R6.2, U3.46
unnamed: R7.1, U3.47
unnamed: R23.2, U3.15
unnamed: R24.1, U3.56
unnamed: R48.2, TP15.1, U8.4
unnamed: R54.1, SW7.1
unnamed: R56.1, U13.5
unnamed: R63.2, U14.3
unnamed: R67.2, U15.3
unnamed: R68.1, U16.3
PWR_LED: C31.1, C32.1, C33.1, C55.1, C56.1, D3.2, D4.2, D5.2, D6.2, D7.2, TP13.1, U10.5, U16.1
PWR_SDCARD: C49.1, J5.4, R8.1, R9.1, R10.1, R11.1, R50.1, R77.1, U15.1
RP2040_RESET: R26.2, TP10.1, U3.26, U4.4
RP2040_SWCLK: TP14.1, U3.24
RP2040_SWDIO: TP9.1, U3.25
SAO0: U3.8, X1.5
SAO1: U3.9, X1.6
SAO2: J11.3, U3.13
SD_CLK: J5.5, R10.2, U7.13
SD_CMD: J5.3, R11.2, R41.2, R42.1, U7.23
SD_D0: J5.7, R9.2, R39.1, U7.24
SPIRAM_CS: R36.2, U5.18, U6.1
SPIRAM_D0: U5.21, U6.5
SPIRAM_D1: U5.13, U6.2
SPIRAM_D2: U5.12, U6.3
SPIRAM_D3: U5.20, U6.7
SPIRAM_SCK: U5.19, U6.6
VBAT: BT1.3, C42.1, RN6.1, SW7.2, U13.3, U14.5
VIN: D9.1, J9.3, R51.2, R52.2, U14.1, U16.5
VUSB: C34.2, C37.2, D9.2, F1.1, R53.1, R55.1, RN6.3, U13.4

File mch2022_bill_of_materials_prototype_4.xlsx (part):

Item | Qty | Reference(s) | Value | Footprint | Datasheet | Buy | Category | Description | Manufacturer | MPN | LCSC | Note
1 | 1 | BT1 |  | Connector_JST:JST_PH_S3B-PH-SM4-TB_1x03-1MP_P2.00mm_Horizontal | https://datasheet.lcsc.com/lcsc/1810261109_JST-Sales-America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 | No | Connectors | Depends on battery, do not yet buy | JST | S3B-PH-SM4-TB(LF)(SN) | C265101 | DO NOT BUY
2 | 5 | C1, C8, C31, C32, C62 | 1u | Capacitor_SMD:C_0402_1005Metric |  | Yes | Capacitors | Generic part | Generic part
3 | 20 | C2, C3, C7, C11, C13, C23, C24, C26, C27, C30, C35, C36, C37, C48, C50, C58, C5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 | 100n | Capacitor_SMD:C_0402_1005Metric |  | Yes | Capacitors | Generic part | Generic part
4 | 6 | C4, C14, C33, C56, C68, C69 | 100n | Capacitor_SMD:C_0402_1005Metric |  | Yes | Capacitors | Generic part | Generic part
5 | 11 | C5, C6, C52, C53, C54, C55, C57, C64, C65, C66, C67 | 47u | Capacitor_SMD:C_0805_2012Metric |  | Yes | Capacitors | Generic part | Generic part
6 | 6 | C9, C10, C28, C29, C40, C41 | 22p | Capacitor_SMD:C_0402_1005Metric |  | Yes | Capacitors | Generic part | Generic part
7 | 8 | C12, C15, C16, C18, C19, C20, C21, C22 | 100n | Capacitor_SMD:C_0402_1005Metric |  | Yes | Capacitors | Generic part | Generic part
8 | 1 | C17 | 10u | Capacitor_SMD:C_0402_1005Metric |  | Yes | Capacitors | Generic part | Generic part
9 | 3 | C25, C34, C42 | 10u | Capacitor_SMD:C_0402_1005Metric |  | Yes | Capacitors | Generic part | Generic part
10 | 7 | C38, C39, C43, C44, C45, C46, C49 | 22u | Capacitor_SMD:C_0805_2012Metric |  | Yes | Capacitors | Generic part | Generic part
11 | 2 | C47, C51 | 39n | Capacitor_SMD:C_0402_1005Metric |  | Yes | Capacitors | Generic part | Generic part
12 | 1 | D1 | USBLC6-4SC6 | digikey-footprints:SOT23-6L | http://www.st.com/content/ccc/resource/technical/document/da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 | Yes | Circuit Protection | TVS DIODE 5.25V 17V SOT23-6 | STMicroelectronics | USBLC6-4SC6 | C558419
13 | 1 | D2 | RGB-5050 | LED_SMD:LED_RGB_5050-6 | https://datasheet.lcsc.com/lcsc/1811131122_HONGLITRONIC-Hong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 | Yes | LEDs | Generic part | Honglitronic | HL-AF-5060H271BU46FU79GC-S1-THL | C219409
14 | 5 | D3, D4, D5, D6, D7 | SK6805-EC15 | custom:LED_SK6805_EC15_1.5x1.5mm | http://www.normandled.com/upload/202003/SK6805-EC15%20LED%20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 | Yes | LEDs | http://www.normandled.com/Product/view/id/842.html | Normandled | SK6805-EC15
15 | 1 | D8 | IR LED | LED_SMD:LED_0805_2012Metric | https://datasheet.lcsc.com/lcsc/2104131906_XINGLIGHT-XL-2012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 | Yes | LEDs | Infrared transmitter | Xinglight | XL-2012IRC-940 | C965889
16 | 1 | D9 | PSBD3D40V1H | Diode_SMD:D_SOD-323 | https://datasheet.lcsc.com/lcsc/1810251323_Shanghai-Prisemi-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 | Yes | Diodes | Generic part | Shanghai Prisemi Elec | PSBD3D40V1H | C110733
17 | 1 | F1 | 1A | Fuse:Fuse_0805_2012Metric | https://datasheet.lcsc.com/lcsc/1808280424_Brightking-Elec--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 | Yes | Fuses | Generic part | Brightking Elec | SMD0805B050TF | C269104
18 | 1 | J1 | AudioJack3 | custom:Boom-audiojack-PJ-320B | https://datasheet.lcsc.com/lcsc/1811132022_BOOMELE-Boom-Prec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 | Yes | Connectors |  | Boomele | C18594 | C18594
19 | 1 | J2 | USB_C_Receptacle_USB2.0 | Connector_USB:USB_C_Receptacle_HRO_TYPE-C-31-M-12 | https://datasheet.lcsc.com/lcsc/2108131730_Korean-Hroparts-E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 | Yes | Connectors |  | Korean Hroparts Elec | TYPE-C-31-M-12 | C165948
20 | 1 | J3 | I2C | custom:1X04_1MM_RA_GND | https://datasheet.lcsc.com/lcsc/1811151533_JST-Sales-America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 | Yes | Connectors | Optional | JST | SM04B-SRSS-TB | C160404
21 | 1 | J4 | PMOD | Connector_PinSocket_2.54mm:PinSocket_2x06_P2.54mm_Horizontal | https://www.cjt.com/Upload/A2541.pdf | No | Connectors | DO NOT POPULATE | CJT | A2541HWR-2x6P | C239357 | DO NOT BUY
22 | 1 | J5 | Micro SD card | custom:MicroSD-SOFNG-TF-002-H18 | http://katalog.we-online.de/em/datasheet/693072010801.pdf | Yes | Connectors |  | SOFNG | TF-002X-H18 | C125814
23 | 1 | J7 | LCD | Connector_FFC-FPC:Hirose_FH12-40S-0.5SH_1x40-1MP_P0.50mm_Horizontal | https://datasheet.lcsc.com/lcsc/2109221430_XUNPU-FPC-05F-40P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 | Yes | Connectors |  | XUNPU | FPC-05F-40PH20 | C2856812
24 | 2 | L3, L4 | 2.2u | custom:Inductor_MSC20FC | https://datasheet.lcsc.com/lcsc/1912111437_PSA-Prosperity-Di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 | Yes | Inductors |  | PSA | MCS20FC-2R2MHC | C375944
25 | 1 | LS1 | Speaker | Connector_Molex:Molex_PicoBlade_53261-0271_1x02-1MP_P1.25mm_Horizontal | ~ | No | Connectors |  |  |  |  | DO NOT BUY
26 | 3 | Q1, Q2, Q3 | AP2302B | Package_TO_SOT_SMD:SOT-23 | https://datasheet.lcsc.com/lcsc/1912111437_ALLPOWER-ShenZhen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 | Yes | Transistors | Generic part (NMOS GSD) | Allpower | AP2302B | C406812
27 | 2 | R1, R2 | 5.1k | Resistor_SMD:R_0402_1005Metric |  | Yes | Resistors | Generic part |  | 0402WGF5101TCE | C25905
28 | 5 | R3, R40, R43, R44, R63 | 4.7k | Resistor_SMD:R_0402_1005Metric |  | Yes | Resistors | Generic part | Uni-royal | 0402WGJ0472TCE | C25940
29 | 9 | R4, R5, R12, R13, R14, R15, R22, R23, R51 | 47 | Resistor_SMD:R_0402_1005Metric |  | Yes | Resistors | Generic part
30 | 2 | R6, R7 | 27 | Resistor_SMD:R_0402_1005Metric |  | Yes | Resistors | Generic part |  | CR0402-JW-270GLF | C203147
31 | 22 | R8, R9, R10, R11, R26, R27, R28, R29, R30, R37, R38, R41, R45, R50, R57, R58, R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 | 10k | Resistor_SMD:R_0402_1005Metric |  | Yes | Resistors | Generic part
32 | 7 | R16, R17, R18, R19, R20, R21, R59 | 100k | Resistor_SMD:R_0402_1005Metric |  | Yes | Resistors | Generic part
33 | 4 | R24, R25, R53, R56 | 1k | Resistor_SMD:R_0402_1005Metric |  | Yes | Resistors | Generic part | Uni-royal | 0402WGJ0102TCE | C25543
34 | 4 | R31, R32, R35, R36 | 10k | Resistor_SMD:R_0402_1005Metric |  | Yes | Resistors | Generic part
35 | 1 | R33 | 47 | Resistor_SMD:R_0402_1005Metric |  | Yes | Resistors | Generic part
36 | 4 | R34, R47, R48, R49 | 4.7k | Resistor_SMD:R_0402_1005Metric |  | Yes | Resistors | Generic part | Uni-royal | 0402WGJ0472TCE | C25940
37 | 3 | R39, R42, R60 | 45.3k | Resistor_SMD:R_0402_1005Metric |  | Yes | Resistors | Generic part |  | 0402WGF4532TCE | C26980
38 | 2 | R46, R52 | 4.7 | Resistor_SMD:R_0402_1005Metric |  | Yes | Resistors | Generic part |  | AC0402FR-0710KL | C144807
39 | 1 | R54 | 22 | Resistor_SMD:R_0402_1005Metric |  | Yes | Resistors | Generic part
40 | 4 | RN1, RN4, RN5, RN7 | 47 | Resistor_SMD:R_Array_Convex_4x0603 | https://datasheet.lcsc.com/lcsc/1912111437_UNI-ROYAL-Uniroya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 | Yes | Resistor arrays | Generic part | Uni-royal | 4D03WGF470JT5E | C425204
41 | 3 | RN2, RN3, RN6 | 100k | Resistor_SMD:R_Array_Convex_4x0603 | https://datasheet.lcsc.com/lcsc/1810010334_UNI-ROYAL-Uniroya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 | Yes | Resistor arrays | Generic part | Uni-royal | 4D03WGF1003T5E | C173315
42 | 1 | S1 | JS1400BFQ | custom:SW_JS1400BFQ | https://datasheet.lcsc.com/lcsc/1809191940_ALPSALPINE-SKRHAB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 | Yes | Buttons | Joystick | Alpsalpine | SKRHABE010 | C139794
43 | 6 | SW1, SW2, SW3, SW4, SW5, SW6 | SKPMAME010 | custom:1TS009 | https://datasheet.lcsc.com/lcsc/1811111111_ALPSALPINE-SKPMAM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 | Yes | Buttons | Push button (notice: prefer this exact type) | Alpsalpine | SKPMAME010 | C115348
44 | 2 | SW7, SW8 | Switch | Button_Switch_SMD:SW_SPDT_PCM12 | https://datasheet.lcsc.com/lcsc/2110151630_XKB-Connectivity-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 | Yes | Buttons | Toggle switch | XKB Connectivity | SK-3296S-01-L1 | C319020
45 | 1 | U1 | MS4344 | CS4344-CZZ:SOP50P490X110-10N | https://datasheet.lcsc.com/lcsc/2012211837_Hangzhou-Ruimeng-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 | Yes | ICs |  | Hangzhou Ruimeng Tech | MS4344 | C1509050
46 | 1 | U2 | 74LVC1G125 | Package_TO_SOT_SMD:SOT-353_SC-70-5 | http://www.ti.com/lit/sg/scyt129e/scyt129e.pdf | Yes | ICs | IC BUF NON-INVERT 5.5V SC70-5 | Nexperia | 74LVC1G125GW | C703585
47 | 1 | U3 | RP2040 | RP2040:QFN40P700X700X90-57N | https://datasheet.lcsc.com/lcsc/2201101600_Raspberry-Pi-RP20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 | No | ICs | Sponsored part, buy from Raspberry Pi | Raspberry Pi | RP2040 | C2040 | DO NOT BUY
48 | 1 | U4 | D2822M | Package_SO:SOP-8_3.9x4.9mm_P1.27mm | https://datasheet.lcsc.com/lcsc/2111030930_Silicore-D2822M-S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 | Yes | ICs |  | Silicore | D2822M SOP8 | C2837292
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
## KiCad design mch2021_square.kicad_pcb

Board: 4 copper layers, 100.0 x 100.0 mm, 140 parts (37 on the bottom side), 138 nets.

Parts:
BT1: LiPo; S2B-ZR
C1, C2, C36, C37: C_Small; C_0603_1608Metric
C3, C27, C28, C29, C30, C31, C32: 1u; C_0402_1005Metric
C4, C14, C21, C24, C26, C34: 10u; C_0603_1608Metric
C5, C6, C10, C11, C12, C13, C16: 22u; C_0603_1608Metric
C7, C22, C25: 100n; C_0402_1005Metric
C8, C9: 22p; C_0603_1608Metric
C15: 0.1u; C_0603_1608Metric
C17, C18, C20, C23, C33, C35, C38, C39, C40, C41, C42: 100n; C_0603_1608Metric
C19: 2.2n; C_0603_1608Metric
C43, C44: 20pF; C_0603_1608Metric
C45, C46, C47: 100nF; C_0603_1608Metric
D1: RGB-5050; LED_RGB_5050-6
D2: LED; LED_0805_2012Metric_Castellated
D3: CDBU0130R; D_0603_1608Metric
D4, D5, D6, D7, D8, D9: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
H1, H2, H3, H4: MountingHole_Pad; HOLE-M3-COND
J1: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J2, J4: SAO; PinSocket_2x03_P2.54mm_Vertical
J3: AudioJack3; Boom-audiojack-PJ-320B
J5: Micro SD card; MicroSD-SOFNG-TF-002-H18
J6: PMOD; PinSocket_2x06_P2.54mm_Horizontal
J7: LCD; Hirose_FH12-40S-0.5SH_1x40-1MP_P0.50mm_Horizontal
J8: PROG; Tag-Connect_TC2030-IDC-NL_2x03_P1.27mm_Vertical
L1, L2: 2.2u; Inductor_MSC20FC
LS1: Speaker_Crystal; Buzzer_Murata_PKMCS0909E4000-R1
Q1, Q2: Q_NMOS_GSD; SOT-23
R1, R2: 5k1; R_0603_1608Metric
R3, R23, R24: 47; R_0603_1608Metric
R4: 100R; R_0603_1608Metric
R5, R10: 2k; R_0603_1608Metric
R6, R7, R9, R11, R12, R13, R31, R32, R33, R34, R35, R36: 10k; R_0603_1608Metric
R8, R18, R19, R22: 45.3k; R_0603_1608Metric
R14: 3.4k; R_0603_1608Metric
R15, R16: 4k7; R_0603_1608Metric
R17: 75k; R_0603_1608Metric
R20, R21: DNP; R_0603_1608Metric
R25, R27, R28: 100k; R_0603_1608Metric
R26: 100; R_0603_1608Metric
R29, R30: TBD; R_0603_1608Metric
RN1: TBD; R_Array_Convex_4x0603
RN2, RN9, RN10, RN11, RN12: 100k; R_Array_Convex_4x0603
RN3, RN4, RN5, RN6: 10k; R_Array_Convex_4x0603
RN7, RN8, RN13, RN14: 47; R_Array_Convex_4x0603
SW1: Power switch; SW_SPDT_PCM12
U1: IR1261; Vishay_MINICAST-3Pin
U2, U3: SY8079; SOT-23-5
U4: XT4054K421MR-G; SOT-23-5
U5, U6: SY6280AAC; SOT-23-5
U7: MPU-6050; InvenSense_QFN-24_4x4mm_P0.5mm
U8: MPR121Q; QFN-20-1EP_3x3mm_P0.4mm_EP1.65x1.65mm
U9: ESP32-WROVER
U10, U13: 74LVC1G125; SOT-353_SC-70-5
U11: ICE40UP5K-SG48ITR; QFN-48-1EP_7x7mm_P0.5mm_EP5.6x5.6mm
U12: LY68L6400; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.41x3.81mm
U14: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm
Y1: 16MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+1V2: C9.1, C11.1, C13.1, C33.1, L2.1, R9.1, R26.1, U11.5, U11.30
+2V5: D3.1, U11.24
+3V3: BT1.1, C3.2, C8.1, C10.1, C12.1, C14.1, C15.1, C17.1, C20.1, C21.1, C23.1, C24.1, C25.1, C26.1, C38.1, C39.1, C40.1, C41.1, C42.1, C45.1, C46.1, C47.1, D1.4, D1.5, D1.6, D3.2, J2.2, J4.2, J6.1, J6.2, J7.8, J7.29, J7.34, J7.35, J8.6, L1.1, R8.1, R10.2, R15.1, R16.1, R19.1, R21.1, R28.1, R31.1, R35.1, R36.1, RN2.1, RN3.5, RN3.6, RN3.7, RN3.8, RN4.5, RN4.6, RN4.7, RN4.8, RN9.5, RN9.6, RN9.7, RN9.8, SW1.1, U1.3, U4.3, U5.5, U6.5, U7.8, U7.13, U8.20, U9.2, U10.5, U11.1, U11.22, U11.33, U12.8, U13.5, U14.1, U14.9, U14.24, U14.36, U14.48
/ACCELEROMETER/AUX_SCL: J2.3, R16.2, U7.7
/ACCELEROMETER/AUX_SDA: J2.4, R15.2, U7.6
/ACCELEROMETER/I2C_SCL: J4.3, RN4.3, U7.23, U8.2, U9.33, U14.42
/ACCELEROMETER/I2C_SDA: J4.4, RN4.4, U7.24, U8.3, U9.36, U14.43
/ACCELEROMETER/IRQ: RN3.1, U7.12, U8.1, U9.4
/CC1: J1.A5, R1.2
/CC2: J1.B5, R2.2
/ESP32/ESP32_BL: RN4.2, U9.25, U14.3
/ESP32/ESP32_EN: RN4.1, U9.3, U14.2
/ESP32/ESP32_RX: U9.34, U14.30
/ESP32/ESP32_TX: U9.35, U14.31
/ESP32/IR_RX: U1.1, U9.6
/ESP32/IR_TX: R4.2, U9.31
/ESP32/LCD_DC: RN7.3, U9.29
/ESP32/PWR_SDCARD_ENABLE: R11.2, U5.4, U9.9
/ESP32/SD_CLK: J5.5, RN5.3, U9.13
/ESP32/SD_D1: J5.8, RN6.7, U9.26
/ESP32/SD_D3: J5.2, RN6.5, U9.16
/ESP32/SPI_CLK: U9.30, U10.2, U11.15, U14.15
/ESP32/SPI_CS_A: R33.2, U9.12, U14.20
/ESP32/SPI_CS_B: R34.2, U9.8, U14.39
/ESP32/SPI_MISO: U9.7, U11.14, U14.16
/ESP32/SPI_MOSI: J7.28, U9.37, U11.17, U14.17
/FPGA/AUDO_L: C36.2, R29.1, RN1.1
/FPGA/AUDO_R: C37.2, R30.1, RN1.3
/FPGA/CLK: U11.35, U14.29
/FPGA/FPGA_CDONE: R28.2, U11.7, U14.25
/FPGA/FPGA_RESET: R27.1, U11.8, U14.21
/FPGA/IRQ: RN3.2, U9.5, U11.43
/FPGA/LCD_D0: J7.16, RN11.8, U11.25
/FPGA/LCD_D1: J7.15, RN11.7, U11.23
/FPGA/LCD_D2: J7.14, RN11.6, U11.27
/FPGA/LCD_D3: J7.13, RN11.5, U11.26
/FPGA/LCD_D4: J7.12, RN12.8, U11.28
/FPGA/LCD_D5: J7.11, RN12.7, U11.31
/FPGA/LCD_D6: J7.10, RN12.6, U11.32
/FPGA/LCD_D7: J7.9, RN12.5, U11.34
/FPGA/LCD_ENABLE: U11.36, U14.26
/FPGA/LCD_RS: R23.2, U11.38
/FPGA/LCD_WR: RN7.4, U11.42
/FPGA/PMOD_1: J6.12, RN13.3
/FPGA/PMOD_2: J6.10, RN13.1
/FPGA/PMOD_3: J6.8, RN14.7
/FPGA/PMOD_4: J6.6, RN14.5
/FPGA/PMOD_5: J6.11, RN13.4
/FPGA/PMOD_6: J6.9, RN13.2
/FPGA/PMOD_7: J6.7, RN14.8
/FPGA/PMOD_8: J6.5, RN14.6
/FPGA/RGB0: D1.2, U11.39
/FPGA/RGB1: D1.3, U11.40
/FPGA/RGB2: D1.1, U11.41
/FPGA/SPI_CS: R25.1, U11.16
/LCD/BACKLIGHT: RN8.5, RN9.1, U14.19
/LCD/CS: J7.32, RN9.3, U14.4
/LCD/FMARK: J7.33, U11.37
/LED/DATA_IN: D4.4, U13.4
/LED/DATA_OUT: D9.2, R3.2
/POWER/CHARGING: R10.1, U4.1, U14.18
/POWER/FB12: C9.2, R7.1, R9.2, U3.5
/POWER/FB33: C8.2, R6.1, R8.2, U2.5
/POWER/PWR_LED_ENABLE: R12.2, U6.4, U13.1, U14.27
/POWER/SENSE_VBAT: RN2.7, RN2.8, U14.10
/POWER/SENSE_VUSB: RN2.5, RN2.6, U14.11
/POWER/SW12: L2.2, U3.3
/POWER/SW33: L1.2, U2.3
/STM32/FPGA_RX: U11.6, U14.12
/STM32/FPGA_TX: U11.9, U14.13
/STM32/LCD_MODE: R24.2, RN10.8, U14.41
/STM32/LCD_RESET: J7.26, RN9.4, U14.40
/STM32/SAO_IO0: J4.5, U14.45
/STM32/SAO_IO1: J4.6, U14.46
/STM32/STM32_BOOT0: R32.2, U8.19, U14.44
/STM32/STM32_RESET: R35.2, U8.18, U14.7
/STM32/USB_D+: J1.A6, J1.B6, R36.2, U14.33
/STM32/USB_D-: J1.A7, J1.B7, U14.32
ESP32_AUDIO_L: RN1.2, U9.10
ESP32_AUDIO_R: RN1.4, U9.11
GND: BT1.2, C3.1, C4.1, C5.2, C6.2, C7.1, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.1, C19.1, C20.2, C21.2, C22.1, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.1, C37.1, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, D2.1, D4.3, D5.3, D6.3, D7.3, D8.3, D9.3, H1.1, H2.1, H3.1, H4.1, J1.A1, J1.A12, J1.B1, J1.B12, J1.S1, J2.1, J3.S, J4.1, J5.6, J5.9, J6.3, J6.4, J7.4, J7.17, J7.18, J7.19, J7.20, J7.21, J7.22, J7.23, J7.24, J7.25, J7.36, J8.3, LS1.1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
unnamed: C1.1, RN1.7, RN1.8
unnamed: C1.2, J3.T
unnamed: C2.1, J3.R
unnamed: C2.2, RN1.5, RN1.6
unnamed: C18.2, U7.10
unnamed: C19.2, U7.20
unnamed: C22.2, U8.5
unnamed: C34.1, C35.1, R26.2, U11.29
unnamed: C43.1, U14.6, Y1.3
unnamed: C44.1, U14.5, Y1.1
unnamed: D2.2, R4.1
unnamed: D4.2, D5.4
unnamed: D5.2, D6.4
unnamed: D6.2, D7.4
unnamed: D7.2, D8.4
unnamed: D8.2, D9.4
unnamed: J2.6, R3.1
unnamed: J7.1, J7.2, Q2.3, RN9.2, U10.1
unnamed: J7.3, Q2.1, R24.1, RN10.6
unnamed: J7.5, RN8.6
unnamed: J7.6, RN8.7
unnamed: J7.7, RN8.8
unnamed: J7.30, RN7.5, RN7.6, RN10.5
unnamed: J7.31, R23.1, U10.4
unnamed: J8.1, U14.34
unnamed: J8.2, U14.37
unnamed: Q1.1, RN8.4
unnamed: Q1.3, RN8.1, RN8.2, RN8.3
unnamed: R5.1, U4.5
unnamed: R13.2, U5.3
unnamed: R14.1, U6.3
unnamed: R17.1, U8.7
unnamed: R29.2, U11.10
unnamed: R30.2, U11.11
unnamed: RN13.5, U11.48
unnamed: RN13.6, U11.44
unnamed: RN13.7, U11.47
unnamed: RN13.8, U11.46
unnamed: RN14.1, U11.3
unnamed: RN14.2, U11.4
unnamed: RN14.3, U11.2
unnamed: RN14.4, U11.45
unnamed: U13.2, U14.22, U14.28
PWR_LED: C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, D4.1, D5.1, D6.1, D7.1, D8.1, D9.1, U6.1
PWR_SDCARD: C16.1, J5.4, RN5.5, RN5.6, RN5.7, RN5.8, RN6.1, RN6.2, RN6.3, RN6.4, U5.1
SD_CMD: J5.3, R21.2, R22.1, RN5.4, U9.23
SD_D0: J5.7, R18.1, RN6.8, U9.24
SD_D2: J5.1, R19.2, R20.1, RN6.6, U9.14
SPIRAM_CS: R31.2, U11.12, U12.1
SPIRAM_D0: U11.18, U12.5
SPIRAM_D1: U11.19, U12.2
SPIRAM_D2: U11.20, U12.3
SPIRAM_D3: U11.21, U12.7
SPIRAM_SCK: U11.13, U12.6
SPK: LS1.2, U14.38
VIN: C5.1, C6.1, SW1.2, U2.1, U2.4, U3.1, U3.4
VUSB: C4.2, C7.2, J1.A4, J1.A9, J1.B4, J1.B9, RN2.3, SW1.3, U4.4

## Commit log

2020-08-09 Finished work on initial schematic
2020-08-09 Small fixes
2020-08-10 SPI RAM for the FPGA
2020-08-10 Fixes, removed I2S DAC
2020-08-24 Dump.
2020-08-26 Removed outdated pdf
2020-08-26 Removed another outdated pdf
2020-08-27 Dump!
2020-08-28 33 DRC errors to go...
2020-08-29 Routed and 0 DRC errors
2020-08-29 Small tweaks
2020-08-29 Final touches
2020-08-30 Moved SAO2/3, I2C_SDA/SCL away from antenna, and LCD/CS away from hole in PCB.
2020-09-19 Add interactive BOM, add pin 1 markers to stm32 and ice40
2020-09-20 Remove lock
2020-11-13 Work in progress: prototype 2
2020-11-22 More work on prototype 2
2020-11-29 Add testpoints, add way for STM32 to wake-up ESP32 from deep sleep
2020-12-06 Schematic for prototype 2 is now complete, time for review! :D
2020-12-12 Solve multiple reported issues in schematic
2020-12-12 Add symbol and footprints for common mode chokes.
2020-12-13 Add L_Core_Ferrite_Coupled_Small_GND library to project table.
2020-12-13 schematic: Improve pin assignement for FPGA
    Related to issues #22, #24, #25 and #30
2020-12-13 Update date & pdf schematic
2020-12-18 Add chokes to usb lines
2020-12-18 Add jumpers
2020-12-22 Updated schematic, add design file
2020-12-27 Update artwork
2020-12-27 Remove trash files
2020-12-29 First steps of routing prototype 2, switch to 0402 for most passives
2020-12-30 More routing...
2021-01-04 Some more work
2021-01-06 Remove conflicting copper for SAO connector
2021-01-06 Layout+initial full routing
2021-01-06 Reroute SPI to reduce branching
2021-01-07 Add layer indicator under SD socket
2021-01-08 Moar fixes
2021-01-08 Small change to some vias on the PCB and attempt at new outline
2021-01-08 Add via-reinforced SMD holddown pads to USB connector, headphone connector and battery connector
2021-01-10 Added expansion header, moved sdcard
2021-01-10 Change power routing, add reference planes to SPI and SDIO along their entire length
2021-01-10 Clean up reference designator silkscreen
    move badgeteam logo, fix FM module trace width
2021-01-10 more small silkscreen tweaks
2021-01-10 Add Proto Areas
2021-01-10 fix: remove mask on all proto areas
2021-01-10 add silscreen fills on the back for name/notes
2021-01-11 Add extra IO header, add battery NTC connection
2021-01-11 Route signals to proto area and battery temp sensor
2021-01-12 Change PMOD, add silkscreen labels
2021-01-12 Change proto area a bit
2021-01-12 Remove paste layer from prototyping area pins
2021-01-12 Change button LCSC id (and 3d stuff)
2021-01-13 move capacitor out of antenna area
2021-01-14 Implement martling's suggestions re: converter layout. Fixes #49
2021-01-14 Reroute VIN and add a reference plane immediately below VIN trace everywhere. Fixes #50
2021-01-14 Add ground around vin trace on top edge as per #50
2021-01-14 Move VIN trace
2021-01-14 ground plane for vin trace
2021-01-14 Cosmetic fix for shielding trace
2021-01-14 Small last minute fixes
2021-01-14 Update LCSC code for the 32kHz crystals
2021-01-15 Add gerbers
2021-01-16 Silkscreen fixes
2021-01-21 Update BOM
2021-01-24 Zip file and pos files
2021-01-24 Update bom: indicate more clearly which components are DNP and which items aren't components at all
2021-04-05 Fix ground connections on J7 and U8
2021-04-05 Change revision number in silkscreen to 2.1
2021-10-09 Fix most of the bugs found on prototype 2 board
2021-10-31 Change pinout of expansion header close to board edge to be fully ground instead of gnd + 3.3v (& update component references)
2021-11-13 Fix symbol of 5050 led and rotate footprint to match actual LED pinout
2021-11-13 Remove old gerbers and schematic pdf
2021-11-13 Fix SK6805-EC15 footprint and symbol
2021-11-14 Add hooks
2021-11-14 Add gerbers, add schematic pdf, update bom
2021-11-28 Initial steps for RP2040
2021-11-28 Connect GPIOs of the RP2040
2021-11-28 Remove stm32 schematic file
2021-11-30 More work on RP2040 integration
2021-12-04 More wiring for the RP2040
2021-12-10 First routing pass done, no unrouted tracks except flash chip missing and DRC doesn't yet pass
2021-12-12 Add flash chip footprint, fix routing of flash chip, fix DRC errors
2021-12-19 Add oscillator for ICE40, add testpoints for unused RP2040 pins
2021-12-19 Move a wire and silkscreen fixes
2021-12-19 Add 1k resistor for RP2040 crystal, add schematic PDF
2021-12-19 Cleanup
2021-12-23 Last fixes before ordering
2021-12-24 And of course fix the mistakes I find after ordering :(
2022-01-14 New gerbers
2022-01-14 Kicad 6
2022-01-14 Prototype 4
2022-01-14 Fix badge on battery power issue, change bootsel resistor value
2022-01-14 Create LICENSE
2022-01-15 Small DRC fixes
2022-02-05 Added audio amplifier TDA2822
    Added an audio sheet, moved all the audio stuff there
    Implemented TDA 2822 amplifier
    Component choice and tuning need doing, putting a 100uF to 470uF electrolytic caps for DC bypass would be expensive
2022-02-05 Fixed graphics and names
2022-03-11 Remove IO expander, move around signals
2022-03-11 Remove buttons schematic sheet
2022-03-14 Remove user I2C bus, connect LCD control signals to ESP32 directly, replace I2S dac
2022-03-16 Use correct flash chip for RP2040
2022-03-20 Add amplifier and spekaer, fixes
2022-03-20 Finishing touches for audio circuit
2022-03-21 Add some footprints
2022-03-22 Bill of materials 1/2
2022-03-22 Add new design files
2022-03-24 Add more info to BOM
2022-03-25 Add IR transmitter, modify bill of materials
2022-03-25 Add passives to BOM
2022-03-27 Artwork stuff
2022-03-27 Swap led data and sd power on ESP32, add speaker grill
2022-03-28 Add lanyard holes, component placement
2022-03-29 Got some of the routing done
2022-03-29 Finished the routing
2022-04-01 0 DRC errors, lots of warnings left to fix
2022-04-02 Last minute fixes
2022-04-02 Last minute changes part 2
2022-04-03 Last minute changes: add some more ground stitching
2022-04-03 Small changes
2022-04-03 Final version of prototype 4
2022-04-03 Prototype 4 done!
2022-04-23 Small last minute tweaks
2022-04-24 Pre-production final design
2022-04-24 Add gerbers, add schematic, finalize design
2022-04-24 Remove backup files
2022-04-24 Add component placement files
2022-04-24 have you tried switching the polarity?
2022-05-09 Change value of R54 to 27 ohm
2022-05-09 Updated R54 in PnP file
2022-05-11 Modify tilde.industries brand name in README
2022-05-15 Add test points to debug FPGA SPI bus.
2022-06-30 Mark diode as DNP, replace fuse with SMD0805B110TF
2022-11-10 Add CodeQL workflow for GitHub code scanning
