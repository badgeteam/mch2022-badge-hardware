File: fpga.sch (KiCad schematic (older format))
At the start: 10 parts

Commit message: Finished work on initial schematic
Parts:
- added J6: PMOD1, symbol Connector_Generic:Conn_02x06_Counter_Clockwise
- gave numbers to parts that had none: 7
Connections:
- net +3V3: now also U6.33 (VCCIO_0), J6.6 (Pin_6), J6.7 (Pin_7)
- net GND: now also J6.5 (Pin_5), J6.8 (Pin_8)
- net LCD_D1: now reaches U6.23 (IOT_37a)
- net LCD_D0: now reaches U6.25 (IOT_36b)
- net LCD_D3: now reaches U6.26 (IOT_39a)
- net LCD_D2: now reaches U6.27 (IOT_38b)
- net LCD_D4: now reaches U6.28 (IOT_41a)
- net LCD_D5: now reaches U6.31 (IOT_42b)
- net LCD_D6: now reaches U6.32 (IOT_43a)
- net LCD_D7: now reaches U6.34 (IOT_44b)
- net CLK: now reaches U6.35 (IOT_46b_G0)
- net LCD_ENABLE: now reaches U6.36 (IOT_48b)
- net LCD_FMARK: now reaches U6.37 (IOT_45a_G1)
- net LCD_RS: now reaches U6.38 (IOT_50b)
- net RGB0: now reaches U6.39 (RGB0)
- net RGB1: now reaches U6.40 (RGB1)
- net RGB2: now reaches U6.41 (RGB2)
- net LCD_WR: now reaches U6.42 (IOT_51a)
- net LCD_CS: now reaches U6.43 (IOT_49a)
- net I2C_SCL: now reaches U6.10 (IOB_18a)
- net I2C_SDA: now reaches U6.11 (IOB_20a)
- net I2S_OUT_BCLK: now reaches U6.12 (IOB_22b)
- net I2S_OUT_DATA: now reaches U6.13 (IOB_24a)
- net I2S_IN_DATA: now reaches U6.18 (IOB_31b)
- net I2S_IN_LRCK: now reaches U6.19 (IOB_29b)
- net I2S_IN_BCLK: now reaches U6.20 (IOB_25b_G3)
- net I2S_OUT_LRCK: now reaches U6.21 (IOB_23b)
- net UART_RX: now reaches U6.6 (IOB_13b)
- net UART_TX: now reaches U6.9 (IOB_16a)
- net PMOD1_IO6: now reaches U6.2 (IOB_6a)
- net PMOD1_IO6: now also J6.11 (Pin_11)
- net PMOD1_IO8: now reaches U6.3 (IOB_9b)
- net PMOD1_IO8: now also J6.9 (Pin_9)
- net PMOD1_IO7: now reaches U6.4 (IOB_8a)
- net PMOD1_IO7: now also J6.10 (Pin_10)
- net PMOD1_IO3: now reaches U6.44 (IOB_3b_G6)
- net PMOD1_IO3: now also J6.3 (Pin_3)
- net PMOD1_IO5: now reaches U6.45 (IOB_5b)
- net PMOD1_IO5: now also J6.12 (Pin_12)
- net PMOD1_IO1: now reaches U6.46 (IOB_0a)
- net PMOD1_IO1: now also J6.1 (Pin_1)
- net PMOD1_IO2: now reaches U6.47 (IOB_2a)
- net PMOD1_IO2: now also J6.2 (Pin_2)
- net PMOD1_IO4: now reaches U6.48 (IOB_4a)
- net PMOD1_IO4: now also J6.4 (Pin_4)
- net SPI_CS_FPGA renamed SPI_CS
Other:
- moved on the sheet: R14, R16, U6A, U6B, U6C

Commit message: Small fixes
Parts:
- added U?: LY68L6400, symbol spiflash:SPIFLASH_QSPI
Connections:
- net +3V3: now also U6.1 (VCCIO_2), U?.8 (VDD)
- net GND: now also U?.4 (VSS)
Changed lines of the file:
@@
 $Descr A4 11693 8268
 encoding utf-8
-Sheet 3 10
+Sheet 10 10
 Title ""
 Date ""
@@
 Text HLabel 6550 3900 0    39   Output ~ 0
 RGB2
+$Comp
+L power:+3.3V #PWR0159
+U 1 1 5F32B7AB
+P 6900 4450
+F 0 "#PWR0159" H 6900 4300 50  0001 C CNN
+F 1 "+3.3V" H 6915 4623 50  0000 C CNN
+F 2 "" H 6900 4450 50  0001 C CNN
+F 3 "" H 6900 4450 50  0001 C CNN
+	1    6900 4450
+	1    0    0    -1
+$EndComp
+$Comp
+L spiflash:SPIFLASH_QSPI U?
+U 1 1 5F39A7E9
+P 10000 1500
+F 0 "U?" H 10000 2015 50  0000 C CNN
+F 1 "LY68L6400" H 10000 1924 50  0000 C CNN
+F 2 "" H 10050 650 60  0001 C CNN
+F 3 "" H 10050 650 60  0001 C CNN
+	1    10000 1500
+	1    0    0    -1
+$EndComp
+$Comp
+L power:+3.3V #PWR?
+U 1 1 5F3A7E70
+P 10500 1200
+F 0 "#PWR?" H 10500 1050 50  0001 C CNN
+F 1 "+3.3V" H 10515 1373 50  0000 C CNN
+F 2 "" H 10500 1200 50  0001 C CNN
+F 3 "" H 10500 1200 50  0001 C CNN
+	1    10500 1200
+	1    0    0    -1
+$EndComp
+Wire Wire Line
+	10450 1250 10500 1250
+Wire Wire Line
+	10500 1250 10500 1200
+Wire Wire Line
+	10450 1750 10500 1750
+Wire Wire Line
+	10500 1750 10500 1800
+$Comp
+L power:GND #PWR?
+U 1 1 5F3AAB21
+P 10500 1800
+F 0 "#PWR?" H 10500 1550 50  0001 C CNN
+F 1 "GND" H 10505 1627 50  0000 C CNN
+F 2 "" H 10500 1800 50  0001 C CNN
+F 3 "" H 10500 1800 50  0001 C CNN
+	1    10500 1800
+	1    0    0    -1
+$EndComp
 $EndSCHEMATC

Commit message: SPI RAM for the FPGA
Parts:
- added C? (x5): 100n, Capacitor_SMD:C_0603_1608Metric, symbol Device:C_Small
- added R?: 10k, symbol Device:R_Small
- added R?: 100k, symbol Device:R_Small
Connections:
- net I2C_SCL is gone; now on net I2S_OUT_BCLK: U6.10 (IOB_18a)
- net I2C_SDA is gone; now on net I2S_OUT_LRCK: U6.11 (IOB_20a)
- net I2S_IN_BCLK is gone; now on net SPIRAM_D2: U6.20 (IOB_25b_G3)
- net I2S_IN_DATA is gone; now on net SPIRAM_D0: U6.18 (IOB_31b)
- net I2S_IN_LRCK is gone; now on net SPIRAM_D1: U6.19 (IOB_29b)
- net LCD_CS is gone; now on net SPIRAM_CS: U6.43 (IOT_49a)
- net +3V3: now also C?.1, C?.1, C?.1, C?.1, C?.1, R?.1
- net GND: now also C?.2, C?.2, C?.2, C?.2, C?.2, R?.2
- net I2S_OUT_BCLK: no longer U6.12 (IOB_22b)
- net I2S_OUT_DATA: now also U6.12 (IOB_22b); no longer U6.13 (IOB_24a)
- net I2S_OUT_LRCK: no longer U6.21 (IOB_23b)
- net SPI_CS: now also R?.1
- net SPIRAM_CS: now reaches U?.1 (~CS)
- net SPIRAM_CS: now also R?.2
- net SPIRAM_D1: now reaches U?.2 (MISO/IO1)
- net SPIRAM_D2: now reaches U?.3 (IO2)
- net SPIRAM_D0: now reaches U?.5 (MOSI/IO0)
- net SPIRAM_SCK: now reaches U?.6 (SCK)
- net SPIRAM_SCK: now also U6.13 (IOB_24a)
- net SPIRAM_D3: now reaches U?.7 (IO3)
- net SPIRAM_D3: now also U6.21 (IOB_23b)
Other:
- moved on the sheet: J6, R14, R16, U6A, U6B, U6C

Commit message: Fixes, removed I2S DAC
Parts:
- removed J6: PMOD1, symbol Connector_Generic:Conn_02x06_Counter_Clockwise
- added C? (x2): C_Small, symbol Device:C_Small
- added R? (x2): TBD, symbol Device:R_Small
- added RN? (x2): 47, symbol Device:R_Pack04
Connections:
- net I2S_OUT_DATA is gone; now on net SPIRAM_CS: U6.12 (IOB_22b)
- net GND: now also C?.1, C?.1
- net SPIRAM_CS: no longer U6.43 (IOT_49a)
- net I2S_OUT_BCLK: no longer names the net of U6.10 (IOB_18a)
- net I2S_OUT_BCLK: now also R?.2
- net I2S_OUT_LRCK: no longer names the net of U6.11 (IOB_20a)
- net I2S_OUT_LRCK: now also R?.2
- net PMOD1_IO1: no longer names the net of U6.46 (IOB_0a)
- net PMOD1_IO1: now also RN?.8 (R1.2)
- net PMOD1_IO2: no longer names the net of U6.47 (IOB_2a)
- net PMOD1_IO2: now also RN?.7 (R2.2)
- net PMOD1_IO3: no longer names the net of U6.44 (IOB_3b_G6)
- net PMOD1_IO3: now also RN?.6 (R3.2)
- net PMOD1_IO4: no longer names the net of U6.48 (IOB_4a)
- net PMOD1_IO4: now also RN?.5 (R4.2)
- net PMOD1_IO5: no longer names the net of U6.45 (IOB_5b)
- net PMOD1_IO5: now also RN?.4 (R4.1)
- net PMOD1_IO6: no longer names the net of U6.2 (IOB_6a)
- net PMOD1_IO6: now also RN?.3 (R3.1)
- net PMOD1_IO7: no longer names the net of U6.4 (IOB_8a)
- net PMOD1_IO7: now also RN?.2 (R2.1)
- net PMOD1_IO8: no longer names the net of U6.3 (IOB_9b)
- net PMOD1_IO8: now also RN?.1 (R1.1)
- new net AUDO_L: C?.2, R?.1
- new net AUDO_R: C?.2, R?.1
- new net IRQ: U6.43 (IOT_49a)
- new net PMOD_1: RN?.1 (R1.1)
- new net PMOD_2: RN?.2 (R2.1)
- new net PMOD_3: RN?.3 (R3.1)
- new net PMOD_4: RN?.4 (R4.1)
- new net PMOD_5: RN?.5 (R4.2)
- new net PMOD_6: RN?.6 (R3.2)
- new net PMOD_7: RN?.7 (R2.2)
- new net PMOD_8: RN?.8 (R1.2)
Other:
- moved on the sheet: U6A, U6B, U6C

Commit message: Dump.
Parts:
- added R37: 4k7, Resistor_SMD:R_0603_1608Metric, symbol Device:R_Small
- C33: renamed from C14; footprint (none) -> Capacitor_SMD:C_0603_1608Metric; LCSC (none) -> C14663; Mouser (none) -> -; Price (none) -> 0.0020; Sponsored (none) -> N
- C34: renamed from C15; footprint (none) -> Capacitor_SMD:C_0603_1608Metric; Price (none) -> 0.0020; Sponsored (none) -> N
- C35: renamed from C16; footprint (none) -> Capacitor_SMD:C_0603_1608Metric; LCSC (none) -> C14663; Mouser (none) -> -; Price (none) -> 0.0020; Sponsored (none) -> N
- C36, C37: renamed from C?; footprint (none) -> Capacitor_SMD:C_0603_1608Metric; Price (none) -> 0.0020; Sponsored (none) -> N
- C38, C39, C40, C41, C42: renamed from C?; LCSC (none) -> C14663; Mouser (none) -> -; Price (none) -> 0.0020; Sponsored (none) -> N
- R25, R29, R30, R31: renamed from R?; footprint (none) -> Resistor_SMD:R_0603_1608Metric; LCSC (none) -> -; Mouser (none) -> -; Price (none) -> 0.0005; Sponsored (none) -> N
- R26: renamed from R15; footprint (none) -> Resistor_SMD:R_0603_1608Metric; LCSC (none) -> C25201; Mouser (none) -> -; Price (none) -> 0.0005; Sponsored (none) -> N
- R27: renamed from R14; footprint (none) -> Resistor_SMD:R_0603_1608Metric; LCSC (none) -> -; Mouser (none) -> -; Price (none) -> 0.0005; Sponsored (none) -> N
- R28: renamed from R16; footprint (none) -> Resistor_SMD:R_0603_1608Metric; LCSC (none) -> -; Mouser (none) -> -; Price (none) -> 0.0005; Sponsored (none) -> N
- RN13, RN14: renamed from RN?; footprint (none) -> Resistor_SMD:R_Array_Convex_4x0603; LCSC (none) -> -; Mouser (none) -> -; Price (none) -> 0.0042; Sponsored (none) -> N
- U11: renamed from U6; LCSC (none) -> -; Mouser (none) -> 842-40UP5KSG48ITR; Price (none) -> 5.29; Sponsored (none) -> N
- U12: renamed from U?; footprint (none) -> Package_SO:SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.41x3.81mm; LCSC (none) -> C261881; Mouser (none) -> -; Price (none) -> 0.64; Sponsored (none) -> Y
Connections:
- net +3V3: now also R37.1
- net CLK: now also U11.37 (IOT_45a_G1); no longer U11.35 (IOT_46b_G0)
- net IRQ: now also R37.2
- net LCD_D0: now also U11.26 (IOT_39a); no longer U11.25 (IOT_36b)
- net LCD_D1: now also U11.27 (IOT_38b); no longer U11.23 (IOT_37a)
- net LCD_D2: now also U11.28 (IOT_41a); no longer U11.27 (IOT_38b)
- net LCD_D3: now also U11.31 (IOT_42b); no longer U11.26 (IOT_39a)
- net LCD_D4: now also U11.32 (IOT_43a); no longer U11.28 (IOT_41a)
- net LCD_D5: now also U11.34 (IOT_44b); no longer U11.31 (IOT_42b)
- net LCD_D6: now also U11.35 (IOT_46b_G0); no longer U11.32 (IOT_43a)
- net LCD_D7: now also U11.36 (IOT_48b); no longer U11.34 (IOT_44b)
- net LCD_ENABLE: now also U11.23 (IOT_37a); no longer U11.36 (IOT_48b)
- net LCD_FMARK: now also U11.25 (IOT_36b); no longer U11.37 (IOT_45a_G1)
- net PMOD_1: now also RN13.3 (R3.1); no longer RN13.1 (R1.1)
- net PMOD_2: now also RN13.1 (R1.1); no longer RN13.2 (R2.1)
- net PMOD_3: now also RN14.7 (R2.2); no longer RN13.3 (R3.1)
- net PMOD_4: now also RN14.5 (R4.2); no longer RN13.4 (R4.1)
- net PMOD_5: now also RN13.4 (R4.1); no longer RN14.5 (R4.2)
- net PMOD_6: now also RN13.2 (R2.1); no longer RN14.6 (R3.2)
- net PMOD_7: now also RN14.8 (R1.2); no longer RN14.7 (R2.2)
- net PMOD_8: now also RN14.6 (R3.2); no longer RN14.8 (R1.2)

Commit message: Dump.
Parts:
- renumbered C33 to C27, C34 to C28, C35 to C29, C36 to C30, C37 to C31, C38 to C32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
