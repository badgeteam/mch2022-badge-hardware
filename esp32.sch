File: esp32.sch (KiCad schematic (older format))
At the start: 31 parts, among them J2 AudioJack3, J4 SAO, U10 MPR121Q, U5 MPU-6050, U5 PCM5100

Commit message: Finished work on initial schematic
Parts:
- removed C11, C13: 100n, Capacitor_SMD:C_0603_1608Metric, symbol Device:C_Small
- removed C11, C13, C32, C?: 100n, Capacitor_SMD:C_0402_1005Metric, symbol Device:C
- removed C12: 2.2n, Capacitor_SMD:C_0603_1608Metric, symbol Device:C_Small
- removed C14, C15, C16, C9: 1u, Capacitor_SMD:C_0402_1005Metric, symbol Device:C
- removed C?: 22u, Capacitor_SMD:C_0603_1608Metric, symbol Device:C
- removed J2: AudioJack3, corelib:Boom-audiojack-PJ-320B, symbol Connector:AudioJack3
- removed J4: SAO, Connector_PinSocket_2.54mm:PinSocket_2x03_P2.54mm_Vertical, symbol Connector_Generic:Conn_02x03_Odd_Even
- removed J?: Micro_SD_Card, corelib:MicroSD-SOFNG-TF-002-H18, symbol Connector:Micro_SD_Card
- removed R17: 75k, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- removed R? (x3): 45.3k, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- removed R? (x2): DNP, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- removed R?: 10k, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- removed RN? (x2): 4.7k, Resistor_SMD:R_Array_Convex_4x0603, symbol Device:R_Pack04
- removed RN? (x2): 10k, Resistor_SMD:R_Array_Convex_4x0603, symbol Device:R_Pack04
- removed U10: MPR121Q, Package_DFN_QFN:QFN-20-1EP_3x3mm_P0.4mm_EP1.65x1.65mm, symbol mch2021-rescue:MPR121Q-corelib
- removed U5: MPU-6050, Sensor_Motion:InvenSense_QFN-24_4x4mm_P0.5mm, symbol Sensor_Motion:MPU-6050
- removed U5: PCM5100, Package_SO:TSSOP-20_4.4x6.5mm_P0.65mm, symbol Audio:PCM5100
- removed U?: ESP32-WROVER, corelib:ESP32-WROVER, symbol mch2021-rescue:ESP32-WROVER-corelib
- added C21: 100n, Capacitor_SMD:C_0402_1005Metric, symbol Device:C
- added R20: 10k, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- added R21, R22, R25: 45.3k, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- added R23, R24: DNP, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- added RN2, RN3: 4.7k, Resistor_SMD:R_Array_Convex_4x0603, symbol Device:R_Pack04
- added RN4, RN5: 10k, Resistor_SMD:R_Array_Convex_4x0603, symbol Device:R_Pack04
- added U9: ESP32-WROVER, corelib:ESP32-WROVER, symbol mch2021-rescue:ESP32-WROVER-corelib
- gave numbers to parts that had none: 1
Connections:
- net labels added: IRQ_ACCEL, IRQ_FPGA, IRQ_TOUCH
- net labels removed: AUDIO_L, AUDIO_R, FPGA_CDONE, FPGA_RESET, MPR121_IRQ, MPU6050_IRQ, SAO_IO0, SAO_IO1, STM32_BOOT0, STM32_RESET, TOUCH_ACCEPT, TOUCH_BACK, TOUCH_DOWN, TOUCH_HOME, TOUCH_LEFT, TOUCH_MENU, TOUCH_RIGHT, TOUCH_UP
- wire segments 105 -> 52
Other:
- note added: "Pull-up resistors for\n - I2C bus\n - IRQ signals\n - Download mode (IO0)\n - SDIO bus"
- note removed: "I2C, IRQ and ESP32 BOOT pin pull-up"
- note removed: "I2S Audio DAC"
- note removed: "MPR121 touch button interface"
- note removed: "MPU6050 accelerometer and gyroscope"
- note removed: "Output type:\nopen drain"
- note removed: "SAO connector"
- note removed: "SD card slot / JTAG port"
- moved on the sheet: C22

Commit message: Fixes, removed I2S DAC
Parts:
- removed R20: 10k, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- RN2, RN3: value 4.7k -> 10k
Connections:
- net I2S_DATA is gone; now on net SPI_STM32_CS: U9.8 (IO32)
- net I2S_LRCK is gone; now on net LCD_DC: U9.12 (IO27)
- net ESP32_BL: now also RN3.2 (R2.1), U9.25 (IO0); no longer RN2.2 (R2.1)
- net ESP32_EN: now also RN3.1 (R1.1); no longer RN2.1 (R1.1)
- net IRQ_ACCEL: now also RN2.1 (R1.1), U9.6 (IO34); no longer RN3.1 (R1.1), U9.4 (SENSOR_VP)
- net IRQ_FPGA: now also RN2.3 (R3.1); no longer RN3.2 (R2.1)
- net LCD_DC: no longer U9.31 (IO19)
- net SPI_FPGA_CS: now also U9.31 (IO19); no longer U9.10 (IO25)
- net SPI_STM32_CS: no longer U9.25 (IO0)
- net I2S_BCLK renamed AUDIO_R
- removed net STM32_IRQ: RN2.3 (R3.1), U9.6 (IO34)
- new net AUDIO_L: U9.10 (IO25)
- new net IRQ_TOUCH: RN2.2 (R2.1), U9.4 (SENSOR_VP)
Changed lines of the file:
@@
 $Descr A4 11693 8268
 encoding utf-8
-Sheet 5 10
+Sheet 5 9
 Title "MCH2021 badge - ESP32 microcontroller"
 Date "2020-08-08"
@@
 P 8150 4750
 F 0 "RN2" H 8338 4796 50  0000 L CNN
-F 1 "4.7k" H 8338 4705 50  0000 L CNN
+F 1 "10k" H 8338 4705 50  0000 L CNN
 F 2 "Resistor_SMD:R_Array_Convex_4x0603" V 8425 4750 50  0001 C CNN
 F 3 "~" H 8150 4750 50  0001 C CNN
@@
 Text HLabel 4250 4200 2    39   Output ~ 0
 SPI_CLK
-Text HLabel 4250 4300 2    39   Output ~ 0
+Text HLabel 4250 4900 2    39   Output ~ 0
 LCD_DC
 Text HLabel 4250 4400 2    39   Output ~ 0
 I2C_SCL
-Text HLabel 4250 4500 2    39   BiDi ~ 0
-I2C_SDA
 Text HLabel 4250 4600 2    39   Output ~ 0
 SPI_MOSI
-Text HLabel 4250 4700 2    39   Output ~ 0
+Text HLabel 4250 4300 2    39   Output ~ 0
 SPI_FPGA_CS
 Text HLabel 4250 5300 2    39   Input ~ 0
@@
 Text Notes 7000 3450 0    79   ~ 0
 Pull-up resistors for\n - I2C bus\n - IRQ signals\n - Download mode (IO0)\n - SDIO bus
-Text HLabel 7950 4950 3    39   UnSpc ~ 0
+Text HLabel 8600 4950 3    39   UnSpc ~ 0
 ESP32_EN
-Text HLabel 8050 4950 3    39   UnSpc ~ 0
+Text HLabel 8700 4950 3    39   UnSpc ~ 0
 ESP32_BL
 Text HLabel 8900 4950 3    39   UnSpc ~ 0
@@
 Text HLabel 4250 3500 2    39   Output ~ 0
 SPI_LCD_CS
+Text HLabel 4250 3000 2    39   Input ~ 0
+ESP32_BL
+Text HLabel 4250 5000 2    39   Output ~ 0
+SPI_STM32_CS
+Text HLabel 2800 3200 0    39   Input ~ 0
+IRQ_TOUCH
 Text HLabel 4250 5200 2    39   Input ~ 0
-STM32_IRQ
-Text HLabel 4650 2900 2    39   Input ~ 0
-ESP32_BL
-Wire Wire Line
-	4350 2900 4350 3000
-Wire Wire Line
-	4250 3000 4350 3000
-$Comp
-L Device:R R20
-U 1 1 60721520
-P 4500 2900
-F 0 "R20" V 4400 2900 50  0000 C CNN
-F 1 "10k" V 4500 2900 50  0000 C CNN
-F 2 "Resistor_SMD:R_0603_1608Metric" V 4430 2900 50  0001 C CNN
-F 3 "~" H 4500 2900 50  0001 C CNN
-	1    4500 2900
-	0    1    1    0
-$EndComp
-Text HLabel 4650 3000 2    39   Output ~ 0
-SPI_STM32_CS
-Connection ~ 4350 3000
-Wire Wire Line
-	4350 3000 4650 3000
+IRQ_ACCEL
+Text HLabel 8050 4950 3    39   UnSpc ~ 0
+IRQ_TOUCH
 Text HLabel 8150 4950 3    39   UnSpc ~ 0
-STM32_IRQ
-Text HLabel 2800 3100 0    39   Input ~ 0
-IRQ_TOUCH
-Text HLabel 2800 3200 0    39   Input ~ 0
-IRQ_ACCEL
-Text HLabel 8600 4950 3    39   UnSpc ~ 0
-IRQ_TOUCH
-Text HLabel 8700 4950 3    39   UnSpc ~ 0
 IRQ_FPGA
-Text HLabel 4250 4800 2    39   Output ~ 0
-I2S_BCLK
-Text HLabel 4250 4900 2    39   Output ~ 0
-I2S_LRCK
-Text HLabel 4250 5000 2    39   Output ~ 0
-I2S_DATA
 Wire Notes Line
 	6950 2800 11200 2800
@@
 P 8800 4750
 F 0 "RN3" H 8988 4796 50  0000 L CNN
-F 1 "4.7k" H 8988 4705 50  0000 L CNN
+F 1 "10k" H 8988 4705 50  0000 L CNN
 F 2 "Resistor_SMD:R_Array_Convex_4x0603" V 9075 4750 50  0001 C CNN
 F 3 "~" H 8800 4750 50  0001 C CNN
@@
 Wire Wire Line
 	10050 4500 10100 4500
-Wire Wire Line
-	2900 3200 3050 3200
 Text HLabel 2800 3300 0    39   Input ~ 0
 IRQ_FPGA
 Wire Wire Line
-	2800 3200 2900 3200
-Connection ~ 2900 3200
-Wire Wire Line
-	2900 3100 2800 3100
-Wire Wire Line
-	2900 3100 2900 3200
-Wire Wire Line
 	2800 3000 3050 3000
 Wire Wire Line
 	2800 3300 3050 3300
+Text HLabel 4250 4500 2    39   BiDi ~ 0
+I2C_SDA
+Text HLabel 4250 4700 2    39   Output ~ 0
+AUDIO_L
+Text HLabel 4250 4800 2    39   Output ~ 0
+AUDIO_R
+Wire Wire Line
+	2800 3200 3050 3200
+Text HLabel 7950 4950 3    39   UnSpc ~ 0
+IRQ_ACCEL
 $EndSCHEMATC

Commit message: Dump.
Parts:
- removed RN2, RN3, RN4, RN5: 10k, Resistor_SMD:R_Array_Convex_4x0603, symbol Device:R_Pack04
- added R49, R50, R51, R52, R53, R54, R55, R56, R57, R58: 10k, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- C25: renamed from C21; footprint Capacitor_SMD:C_0402_1005Metric -> Capacitor_SMD:C_0603_1608Metric; LCSC (none) -> C14663; Mouser (none) -> -; Price (none) -> 0.0020; Sponsored (none) -> N
- C26: renamed from C22; Price (none) -> 0.0020; Sponsored (none) -> N
- R18: renamed from R21; LCSC (none) -> -; Mouser (none) -> -; Price (none) -> 0.0005; Sponsored (none) -> N
- R19: renamed from R22; LCSC (none) -> -; Mouser (none) -> -; Price (none) -> 0.0005; Sponsored (none) -> N
- R20: renamed from R23; LCSC (none) -> -; Mouser (none) -> -; Price (none) -> 0.0005; Sponsored (none) -> N
- R21: renamed from R24; LCSC (none) -> -; Mouser (none) -> -; Price (none) -> 0.0005; Sponsored (none) -> N
- R22: renamed from R25; LCSC (none) -> -; Mouser (none) -> -; Price (none) -> 0.0005; Sponsored (none) -> N
- U9: footprint corelib:ESP32-WROVER -> custom:ESP32-WROVER; LCSC (none) -> -; Mouser (none) -> -; Price (none) -> 0; Sponsored (none) -> Y
Connections:
- net SPI_LCD_CS is gone; now on net LCD_DC: U9.29 (IO5)
- net +3V3: now also R49.1, R50.1, R51.1, R52.1
- net ESP32_BL: now also R50.2
- net ESP32_EN: now also R49.2
- net I2C_SCL: now also R51.2
- net I2C_SDA: now also R52.2
- net LCD_DC: no longer U9.12 (IO27)
- net PWR_SDCARD: now also R53.1, R54.1, R55.1, R56.1, R57.1, R58.1
- net SD_CLK: now also R53.2
- net SD_CMD: now also R54.2
- net SD_D0: now also R55.2
- net SD_D1: now also R56.2
- net SD_D2: now also R57.2
- net SD_D3: now also R58.2
- net SPI_FPGA_CS renamed IR_TX
- net SPI_STM32_CS renamed SPI_CS_B
- new net SPI_CS_A: U9.12 (IO27)
Other:
- note added: "Also used as STM32 IRQ"
- note added: "Input only"
- note added: "Pull-up resistors for\n - I2C bus\n - Download mode (IO0)\n - SDIO bus"
- note removed: "Pull-up resistors for\n - I2C bus\n - IRQ signals\n - Download mode (IO0)\n - SDIO bus"

Commit message: Dump.
Parts:
- renumbered C25 to C43, C26 to C44, R18 to R35, R49 to R36, R50 to R37, R19 to R38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
Changed lines of the file:
@@
 $EndDescr
 $Comp
-L power:+3.3V #PWR097
+L power:+3.3V #PWR0165
 U 1 1 605756DE
 P 3650 2800
-F 0 "#PWR097" H 3650 2650 50  0001 C CNN
+F 0 "#PWR0165" H 3650 2650 50  0001 C CNN
 F 1 "+3.3V" H 3650 2950 50  0000 C CNN
 F 2 "" H 3650 2800 50  0001 C CNN
@@
 NoConn ~ 3050 4200
 $Comp
-L power:GND #PWR098
+L power:GND #PWR0166
 U 1 1 60721513
 P 3650 5600
-F 0 "#PWR098" H 3650 5350 50  0001 C CNN
+F 0 "#PWR0166" H 3650 5350 50  0001 C CNN
 F 1 "GND" H 3655 5427 50  0000 C CNN
 F 2 "" H 3650 5600 50  0001 C CNN
@@
 $EndComp
 $Comp
-L power:+3.3V #PWR0101
+L power:+3.3V #PWR0169
 U 1 1 60AFAF9F
 P 6600 7150
-F 0 "#PWR0101" H 6600 7000 50  0001 C CNN
+F 0 "#PWR0169" H 6600 7000 50  0001 C CNN
 F 1 "+3.3V" H 6600 7300 50  0000 C CNN
 F 2 "" H 6600 7150 50  0001 C CNN
@@
 $EndComp
 $Comp
-L power:+3.3V #PWR099
+L power:+3.3V #PWR0167
 U 1 1 60575709
 P 6150 7150
-F 0 "#PWR099" H 6150 7000 50  0001 C CNN
+F 0 "#PWR0167" H 6150 7000 50  0001 C CNN
 F 1 "+3.3V" H 6150 7300 50  0000 C CNN
 F 2 "" H 6150 7150 50  0001 C CNN
@@
 	9150 4500 9050 4500
 $Comp
-L power:GND #PWR0102
+L power:GND #PWR0170
 U 1 1 605756D0
 P 6600 7450
-F 0 "#PWR0102" H 6600 7200 50  0001 C CNN
+F 0 "#PWR0170" H 6600 7200 50  0001 C CNN
 F 1 "GND" H 6605 7277 50  0000 C CNN
 F 2 "" H 6600 7450 50  0001 C CNN
@@
 $EndComp
 $Comp
-L power:GND #PWR0100
+L power:GND #PWR0168
 U 1 1 5F61964A
 P 6150 7450
-F 0 "#PWR0100" H 6150 7200 50  0001 C CNN
+F 0 "#PWR0168" H 6150 7200 50  0001 C CNN
 F 1 "GND" H 6155 7277 50  0000 C CNN
 F 2 "" H 6150 7450 50  0001 C CNN
@@
 $EndComp
 $Comp
-L Device:C C25
+L Device:C C43
 U 1 1 605756E3
 P 6150 7300
-F 0 "C25" H 6265 7346 50  0000 L CNN
+F 0 "C43" H 6265 7346 50  0000 L CNN
 F 1 "100n" H 6265 7255 50  0000 L CNN
 F 2 "Capacitor_SMD:C_0603_1608Metric" H 6188 7150 50  0001 C CNN
@@
 $EndComp
 $Comp
-L Device:C C26
+L Device:C C44
 U 1 1 5F619647
 P 6600 7300
-F 0 "C26" H 6715 7346 50  0000 L CNN
+F 0 "C44" H 6715 7346 50  0000 L CNN
 F 1 "10u" H 6715 7255 50  0000 L CNN
 F 2 "Capacitor_SMD:C_0603_1608Metric" H 6638 7150 50  0001 C CNN
@@
 $EndComp
 $Comp
-L power:GND #PWR0109
+L power:GND #PWR0176
 U 1 1 605756F0
 P 9800 2400
-F 0 "#PWR0109" H 9800 2150 50  0001 C CNN
+F 0 "#PWR0176" H 9800 2150 50  0001 C CNN
 F 1 "GND" H 9805 2227 50  0000 C CNN
 F 2 "" H 9800 2400 50  0001 C CNN
@@
 $EndComp
 $Comp
-L Device:R R22
+L Device:R R49
 U 1 1 605756E5
 P 9800 2250
-F 0 "R22" V 9700 2250 50  0000 C CNN
+F 0 "R49" V 9700 2250 50  0000 C CNN
 F 1 "45.3k" V 9900 2250 50  0000 C CNN
 F 2 "Resistor_SMD:R_0603_1608Metric" V 9730 2250 50  0001 C CNN
@@
 SD_D0
 $Comp
-L Device:R R18
+L Device:R R35
 U 1 1 6072151D
 P 8250 2250
-F 0 "R18" V 8150 2250 50  0000 C CNN
+F 0 "R35" V 8150 2250 50  0000 C CNN
 F 1 "45.3k" V 8350 2250 50  0000 C CNN
 F 2 "Resistor_SMD:R_0603_1608Metric" V 8180 2250 50  0001 C CNN
@@
 $EndComp
 $Comp
-L power:GND #PWR0104
+L power:GND #PWR0171
 U 1 1 6072151E
 P 8250 2400
-F 0 "#PWR0104" H 8250 2150 50  0001 C CNN
+F 0 "#PWR0171" H 8250 2150 50  0001 C CNN
 F 1 "GND" H 8255 2227 50  0000 C CNN
 F 2 "" H 8250 2400 50  0001 C CNN
@@
 	9800 2050 9750 2050
 $Comp
-L Device:R R21
+L Device:R R48
 U 1 1 60534310
 P 9800 1850
-F 0 "R21" V 9700 1850 50  0000 C CNN
+F 0 "R48" V 9700 1850 50  0000 C CNN
 F 1 "DNP" V 9900 1850 50  0000 C CNN
 F 2 "Resistor_SMD:R_0603_1608Metric" V 9730 1850 50  0001 C CNN
@@
 $EndComp
 $Comp
-L power:+3.3V #PWR0108
+L power:+3.3V #PWR0175
 U 1 1 605756EE
 P 9800 1700
-F 0 "#PWR0108" H 9800 1550 50  0001 C CNN
+F 0 "#PWR0175" H 9800 1550 50  0001 C CNN
 F 1 "+3.3V" H 9800 1850 50  0000 C CNN
 F 2 "" H 9800 1700 50  0001 C CNN
@@
 Connection ~ 9800 2050
 $Comp
-L power:GND #PWR0107
+L power:GND #PWR0173
 U 1 1 60721519
 P 9000 2400
-F 0 "#PWR0107" H 9000 2150 50  0001 C CNN
+F 0 "#PWR0173" H 9000 2150 50  0001 C CNN
 F 1 "GND" H 9005 2227 50  0000 C CNN
 F 2 "" H 9000 2400 50  0001 C CNN
@@
 	9000 2050 8950 2050
 $Comp
-L Device:R R20
+L Device:R R39
 U 1 1 605756DA
 P 9000 2250
-F 0 "R20" V 8900 2250 50  0000 C CNN
+F 0 "R39" V 8900 2250 50  0000 C CNN
 F 1 "DNP" V 9100 2250 50  0000 C CNN
 F 2 "Resistor_SMD:R_0603_1608Metric" V 8930 2250 50  0001 C CNN
@@
 $EndComp
 $Comp
-L power:+3.3V #PWR0106
+L power:+3.3V #PWR0172
 U 1 1 60721533
 P 9000 1700
-F 0 "#PWR0106" H 9000 1550 50  0001 C CNN
+F 0 "#PWR0172" H 9000 1550 50  0001 C CNN
 F 1 "+3.3V" H 9000 1850 50  0000 C CNN
 F 2 "" H 9000 1700 50  0001 C CNN
@@
 Connection ~ 9000 2050
 $Comp
-L Device:R R19
+L Device:R R38
 U 1 1 60721539
 P 9000 1850
-F 0 "R19" V 8900 1850 50  0000 C CNN
+F 0 "R38" V 8900 1850 50  0000 C CNN
 F 1 "45.3k" V 9100 1850 50  0000 C CNN
 F 2 "Resistor_SMD:R_0603_1608Metric" V 8930 1850 50  0001 C CNN
@@
 Unknown\nLow = UART DL\nHigh = ???
 $Comp
-L power:+3.3V #PWR0105
+L power:+3.3V #PWR0174
 U 1 1 605756F5
 P 9000 4450
-F 0 "#PWR0105" H 9000 4300 50  0001 C CNN
+F 0 "#PWR0174" H 9000 4300 50  0001 C CNN
 F 1 "+3.3V" H 9000 4600 50  0000 C CNN
 F 2 "" H 9000 4450 50  0001 C CNN
@@
 	3950 5350 4150 5350
 $Comp
-L mch2021-rescue:ESP32-WROVER-corelib U9
+L mch2021-rescue:ESP32-WROVER-corelib U13
 U 1 1 605756CA
 P 3650 4200
-F 0 "U9" H 4000 5650 50  0000 C CNN
+F 0 "U13" H 4000 5650 50  0000 C CNN
 F 1 "ESP32-WROVER" H 4000 5550 50  0000 C CNN
 F 2 "custom:ESP32-WROVER" H 3650 2700 50  0001 C CNN
@@
 	2800 3200 3050 3200
 $Comp
-L Device:R R58
+L Device:R R47
 U 1 1 5F4625FA
 P 9750 4750
-F 0 "R58" V 9800 4600 50  0000 C CNN
+F 0 "R47" V 9800 4600 50  0000 C CNN
 F 1 "10k" V 9750 4750 50  0000 C CNN
 F 2 "Resistor_SMD:R_0603_1608Metric" V 9680 4750 50  0001 C CNN
@@
 $EndComp
 $Comp
-L Device:R R57
+L Device:R R46
 U 1 1 5F462EA1
 P 9650 4750
-F 0 "R57" V 9700 4600 50  0000 C CNN
+F 0 "R46" V 9700 4600 50  0000 C CNN
 F 1 "10k" V 9650 4750 50  0000 C CNN
 F 2 "Resistor_SMD:R_0603_1608Metric" V 9580 4750 50  0001 C CNN
@@
 $EndComp
 $Comp
-L Device:R R56
+L Device:R R45
 U 1 1 5F463A31
 P 9550 4750
-F 0 "R56" V 9600 4600 50  0000 C CNN
+F 0 "R45" V 9600 4600 50  0000 C CNN
 F 1 "10k" V 9550 4750 50  0000 C CNN
 F 2 "Resistor_SMD:R_0603_1608Metric" V 9480 4750 50  0001 C CNN
@@
 $EndComp
 $Comp
-L Device:R R55
+L Device:R R44
 U 1 1 5F464767
 P 9450 4750
-F 0 "R55" V 9500 4600 50  0000 C CNN
+F 0 "R44" V 9500 4600 50  0000 C CNN
 F 1 "10k" V 9450 4750 50  0000 C CNN
 F 2 "Resistor_SMD:R_0603_1608Metric" V 9380 4750 50  0001 C CNN
@@
 $EndComp
 $Comp
-L Device:R R54
+L Device:R R43
 U 1 1 5F4653F4
 P 9350 4750
-F 0 "R54" V 9400 4600 50  0000 C CNN
+F 0 "R43" V 9400 4600 50  0000 C CNN
 F 1 "10k" V 9350 4750 50  0000 C CNN
 F 2 "Resistor_SMD:R_0603_1608Metric" V 9280 4750 50  0001 C CNN
@@
 $EndComp
 $Comp
-L Device:R R53
+L Device:R R42
 U 1 1 5F465E5B
 P 9250 4750
-F 0 "R53" V 9300 4600 50  0000 C CNN
+F 0 "R42" V 9300 4600 50  0000 C CNN
 F 1 "10k" V 9250 4750 50  0000 C CNN
 F 2 "Resistor_SMD:R_0603_1608Metric" V 9180 4750 50  0001 C CNN
@@
 	9250 4900 9250 4950
 $Comp
-L Device:R R52
+L Device:R R41
 U 1 1 5F472114
 P 9150 4750
-F 0 "R52" V 9200 4600 50  0000 C CNN
+F 0 "R41" V 9200 4600 50  0000 C CNN
 F 1 "10k" V 9150 4750 50  0000 C CNN
 F 2 "Resistor_SMD:R_0603_1608Metric" V 9080 4750 50  0001 C CNN
@@
 $EndComp
 $Comp
-L Device:R R51
+L Device:R R40
 U 1 1 5F47253D
 P 9050 4750
-F 0 "R51" V 9100 4600 50  0000 C CNN
+F 0 "R40" V 9100 4600 50  0000 C CNN
 F 1 "10k" V 9050 4750 50  0000 C CNN
 F 2 "Resistor_SMD:R_0603_1608Metric" V 8980 4750 50  0001 C CNN
@@
 $EndComp
 $Comp
-L Device:R R50
+L Device:R R37
 U 1 1 5F472778
 P 8950 4750
-F 0 "R50" V 9000 4600 50  0000 C CNN
+F 0 "R37" V 9000 4600 50  0000 C CNN
 F 1 "10k" V 8950 4750 50  0000 C CNN
 F 2 "Resistor_SMD:R_0603_1608Metric" V 8880 4750 50  0001 C CNN
@@
 $EndComp
 $Comp
-L Device:R R49
+L Device:R R36
 U 1 1 5F47298B
 P 8850 4750
-F 0 "R49" V 8900 4600 50  0000 C CNN
+F 0 "R36" V 8900 4600 50  0000 C CNN
 F 1 "10k" V 8850 4750 50  0000 C CNN
 F 2 "Resistor_SMD:R_0603_1608Metric" V 8780 4750 50  0001 C CNN
